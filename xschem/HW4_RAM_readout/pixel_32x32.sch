v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -240 0 -240 70 { lab=OUT0}
N -80 0 -80 70 { lab=OUT1}
N 80 0 80 70 { lab=OUT2}
N -320 -830 -320 -800 { lab=avdd}
N -240 -830 -240 -800 { lab=Vgh}
N -160 -830 -160 -800 { lab=Vgv}
N 80 -830 80 -800 { lab=North}
N 160 -830 160 -800 { lab=West}
N 320 -830 320 -800 { lab=agnd}
N 240 0 240 70 { lab=OUT3}
N 240 -830 240 -800 { lab=SouthEast}
N -460 -160 -400 -160 { lab=SEL3}
N -460 -320 -400 -320 { lab=SEL2}
N -460 -480 -400 -480 { lab=SEL1}
N -460 -640 -400 -640 { lab=SEL0}
N 720 0 720 70 { lab=OUT4}
N 880 0 880 70 { lab=OUT5}
N 1040 0 1040 70 { lab=OUT6}
N 640 -830 640 -800 { lab=avdd}
N 720 -830 720 -800 { lab=Vgh}
N 800 -830 800 -800 { lab=Vgv}
N 1040 -830 1040 -800 { lab=North}
N 1120 -830 1120 -800 { lab=West}
N 1280 -830 1280 -800 { lab=agnd}
N 1200 0 1200 70 { lab=OUT7}
N 1200 -830 1200 -800 { lab=SouthEast}
N 500 -160 560 -160 { lab=SEL3}
N 500 -320 560 -320 { lab=SEL2}
N 500 -480 560 -480 { lab=SEL1}
N 500 -640 560 -640 { lab=SEL0}
N 1680 0 1680 70 { lab=OUT8}
N 1840 0 1840 70 { lab=OUT9}
N 2000 0 2000 70 { lab=OUT10}
N 1600 -830 1600 -800 { lab=avdd}
N 1680 -830 1680 -800 { lab=Vgh}
N 1760 -830 1760 -800 { lab=Vgv}
N 2000 -830 2000 -800 { lab=North}
N 2080 -830 2080 -800 { lab=West}
N 2240 -830 2240 -800 { lab=agnd}
N 2160 0 2160 70 { lab=OUT11}
N 2160 -830 2160 -800 { lab=SouthEast}
N 1460 -160 1520 -160 { lab=SEL3}
N 1460 -320 1520 -320 { lab=SEL2}
N 1460 -480 1520 -480 { lab=SEL1}
N 1460 -640 1520 -640 { lab=SEL0}
N 2640 0 2640 70 { lab=OUT12}
N 2800 0 2800 70 { lab=OUT13}
N 2960 0 2960 70 { lab=OUT14}
N 2560 -830 2560 -800 { lab=avdd}
N 2640 -830 2640 -800 { lab=Vgh}
N 2720 -830 2720 -800 { lab=Vgv}
N 2960 -830 2960 -800 { lab=North}
N 3040 -830 3040 -800 { lab=West}
N 3200 -830 3200 -800 { lab=agnd}
N 3120 0 3120 70 { lab=OUT15}
N 3120 -830 3120 -800 { lab=SouthEast}
N 2420 -160 2480 -160 { lab=SEL3}
N 2420 -320 2480 -320 { lab=SEL2}
N 2420 -480 2480 -480 { lab=SEL1}
N 2420 -640 2480 -640 { lab=SEL0}
N 3600 0 3600 70 { lab=OUT16}
N 3760 0 3760 70 { lab=OUT17}
N 3920 0 3920 70 { lab=OUT18}
N 3520 -830 3520 -800 { lab=avdd}
N 3600 -830 3600 -800 { lab=Vgh}
N 3680 -830 3680 -800 { lab=Vgv}
N 3920 -830 3920 -800 { lab=North}
N 4000 -830 4000 -800 { lab=West}
N 4160 -830 4160 -800 { lab=agnd}
N 4080 0 4080 70 { lab=OUT19}
N 4080 -830 4080 -800 { lab=SouthEast}
N 3380 -160 3440 -160 { lab=SEL3}
N 3380 -320 3440 -320 { lab=SEL2}
N 3380 -480 3440 -480 { lab=SEL1}
N 3380 -640 3440 -640 { lab=SEL0}
N 4560 0 4560 70 { lab=OUT20}
N 4720 0 4720 70 { lab=OUT21}
N 4880 0 4880 70 { lab=OUT22}
N 4480 -830 4480 -800 { lab=avdd}
N 4560 -830 4560 -800 { lab=Vgh}
N 4640 -830 4640 -800 { lab=Vgv}
N 4880 -830 4880 -800 { lab=North}
N 4960 -830 4960 -800 { lab=West}
N 5120 -830 5120 -800 { lab=agnd}
N 5040 0 5040 70 { lab=OUT23}
N 5040 -830 5040 -800 { lab=SouthEast}
N 4340 -160 4400 -160 { lab=SEL3}
N 4340 -320 4400 -320 { lab=SEL2}
N 4340 -480 4400 -480 { lab=SEL1}
N 4340 -640 4400 -640 { lab=SEL0}
N 5520 0 5520 70 { lab=OUT24}
N 5680 0 5680 70 { lab=OUT25}
N 5840 0 5840 70 { lab=OUT26}
N 5440 -830 5440 -800 { lab=avdd}
N 5520 -830 5520 -800 { lab=Vgh}
N 5600 -830 5600 -800 { lab=Vgv}
N 5840 -830 5840 -800 { lab=North}
N 5920 -830 5920 -800 { lab=West}
N 6080 -830 6080 -800 { lab=agnd}
N 6000 0 6000 70 { lab=OUT27}
N 6000 -830 6000 -800 { lab=SouthEast}
N 5300 -160 5360 -160 { lab=SEL3}
N 5300 -320 5360 -320 { lab=SEL2}
N 5300 -480 5360 -480 { lab=SEL1}
N 5300 -640 5360 -640 { lab=SEL0}
N 6480 0 6480 70 { lab=OUT28}
N 6640 0 6640 70 { lab=OUT29}
N 6800 0 6800 70 { lab=OUT30}
N 6400 -830 6400 -800 { lab=avdd}
N 6480 -830 6480 -800 { lab=Vgh}
N 6560 -830 6560 -800 { lab=Vgv}
N 6800 -830 6800 -800 { lab=North}
N 6880 -830 6880 -800 { lab=West}
N 7040 -830 7040 -800 { lab=agnd}
N 6960 0 6960 70 { lab=OUT15}
N 6960 -830 6960 -800 { lab=SouthEast}
N 6260 -160 6320 -160 { lab=SEL3}
N 6260 -320 6320 -320 { lab=SEL2}
N 6260 -480 6320 -480 { lab=SEL1}
N 6260 -640 6320 -640 { lab=SEL0}
N -240 1080 -240 1150 { lab=OUT0}
N -80 1080 -80 1150 { lab=OUT1}
N 80 1080 80 1150 { lab=OUT2}
N -320 250 -320 280 { lab=avdd}
N -240 250 -240 280 { lab=Vgh}
N -160 250 -160 280 { lab=Vgv}
N 80 250 80 280 { lab=North}
N 160 250 160 280 { lab=West}
N 320 250 320 280 { lab=agnd}
N 240 1080 240 1150 { lab=OUT3}
N 240 250 240 280 { lab=SouthEast}
N -460 920 -400 920 { lab=SEL3}
N -460 760 -400 760 { lab=SEL2}
N -460 600 -400 600 { lab=SEL1}
N -460 440 -400 440 { lab=SEL0}
N 720 1080 720 1150 { lab=OUT4}
N 880 1080 880 1150 { lab=OUT5}
N 1040 1080 1040 1150 { lab=OUT6}
N 640 250 640 280 { lab=avdd}
N 720 250 720 280 { lab=Vgh}
N 800 250 800 280 { lab=Vgv}
N 1040 250 1040 280 { lab=North}
N 1120 250 1120 280 { lab=West}
N 1280 250 1280 280 { lab=agnd}
N 1200 1080 1200 1150 { lab=OUT7}
N 1200 250 1200 280 { lab=SouthEast}
N 1680 1080 1680 1150 { lab=OUT8}
N 1840 1080 1840 1150 { lab=OUT9}
N 2000 1080 2000 1150 { lab=OUT10}
N 1600 250 1600 280 { lab=avdd}
N 1680 250 1680 280 { lab=Vgh}
N 1760 250 1760 280 { lab=Vgv}
N 2000 250 2000 280 { lab=North}
N 2080 250 2080 280 { lab=West}
N 2240 250 2240 280 { lab=agnd}
N 2160 1080 2160 1150 { lab=OUT11}
N 2160 250 2160 280 { lab=SouthEast}
N 2640 1080 2640 1150 { lab=OUT12}
N 2800 1080 2800 1150 { lab=OUT13}
N 2960 1080 2960 1150 { lab=OUT14}
N 2560 250 2560 280 { lab=avdd}
N 2640 250 2640 280 { lab=Vgh}
N 2720 250 2720 280 { lab=Vgv}
N 2960 250 2960 280 { lab=North}
N 3040 250 3040 280 { lab=West}
N 3200 250 3200 280 { lab=agnd}
N 3120 1080 3120 1150 { lab=OUT15}
N 3120 250 3120 280 { lab=SouthEast}
N 3600 1080 3600 1150 { lab=OUT16}
N 3760 1080 3760 1150 { lab=OUT17}
N 3920 1080 3920 1150 { lab=OUT18}
N 3520 250 3520 280 { lab=avdd}
N 3600 250 3600 280 { lab=Vgh}
N 3680 250 3680 280 { lab=Vgv}
N 3920 250 3920 280 { lab=North}
N 4000 250 4000 280 { lab=West}
N 4160 250 4160 280 { lab=agnd}
N 4080 1080 4080 1150 { lab=OUT19}
N 4080 250 4080 280 { lab=SouthEast}
N 4560 1080 4560 1150 { lab=OUT20}
N 4720 1080 4720 1150 { lab=OUT21}
N 4880 1080 4880 1150 { lab=OUT22}
N 4480 250 4480 280 { lab=avdd}
N 4560 250 4560 280 { lab=Vgh}
N 4640 250 4640 280 { lab=Vgv}
N 4880 250 4880 280 { lab=North}
N 4960 250 4960 280 { lab=West}
N 5120 250 5120 280 { lab=agnd}
N 5040 1080 5040 1150 { lab=OUT23}
N 5040 250 5040 280 { lab=SouthEast}
N 5520 1080 5520 1150 { lab=OUT24}
N 5680 1080 5680 1150 { lab=OUT25}
N 5840 1080 5840 1150 { lab=OUT26}
N 5440 250 5440 280 { lab=avdd}
N 5520 250 5520 280 { lab=Vgh}
N 5600 250 5600 280 { lab=Vgv}
N 5840 250 5840 280 { lab=North}
N 5920 250 5920 280 { lab=West}
N 6080 250 6080 280 { lab=agnd}
N 6000 1080 6000 1150 { lab=OUT27}
N 6000 250 6000 280 { lab=SouthEast}
N 6480 1080 6480 1150 { lab=OUT28}
N 6640 1080 6640 1150 { lab=OUT29}
N 6800 1080 6800 1150 { lab=OUT30}
N 6400 250 6400 280 { lab=avdd}
N 6480 250 6480 280 { lab=Vgh}
N 6560 250 6560 280 { lab=Vgv}
N 6800 250 6800 280 { lab=North}
N 6880 250 6880 280 { lab=West}
N 7040 250 7040 280 { lab=agnd}
N 6960 1080 6960 1150 { lab=OUT15}
N 6960 250 6960 280 { lab=SouthEast}
N -400 440 6320 440 {}
N -400 600 6320 600 {}
N -400 760 6320 760 {}
N -400 920 6320 920 {}
N -240 2180 -240 2250 { lab=OUT0}
N -80 2180 -80 2250 { lab=OUT1}
N 80 2180 80 2250 { lab=OUT2}
N -320 1350 -320 1380 { lab=avdd}
N -240 1350 -240 1380 { lab=Vgh}
N -160 1350 -160 1380 { lab=Vgv}
N 80 1350 80 1380 { lab=North}
N 160 1350 160 1380 { lab=West}
N 320 1350 320 1380 { lab=agnd}
N 240 2180 240 2250 { lab=OUT3}
N 240 1350 240 1380 { lab=SouthEast}
N -460 2020 -400 2020 { lab=SEL3}
N -460 1860 -400 1860 { lab=SEL2}
N -460 1700 -400 1700 { lab=SEL1}
N -460 1540 -400 1540 { lab=SEL0}
N 720 2180 720 2250 { lab=OUT4}
N 880 2180 880 2250 { lab=OUT5}
N 1040 2180 1040 2250 { lab=OUT6}
N 640 1350 640 1380 { lab=avdd}
N 720 1350 720 1380 { lab=Vgh}
N 800 1350 800 1380 { lab=Vgv}
N 1040 1350 1040 1380 { lab=North}
N 1120 1350 1120 1380 { lab=West}
N 1280 1350 1280 1380 { lab=agnd}
N 1200 2180 1200 2250 { lab=OUT7}
N 1200 1350 1200 1380 { lab=SouthEast}
N 1680 2180 1680 2250 { lab=OUT8}
N 1840 2180 1840 2250 { lab=OUT9}
N 2000 2180 2000 2250 { lab=OUT10}
N 1600 1350 1600 1380 { lab=avdd}
N 1680 1350 1680 1380 { lab=Vgh}
N 1760 1350 1760 1380 { lab=Vgv}
N 2000 1350 2000 1380 { lab=North}
N 2080 1350 2080 1380 { lab=West}
N 2240 1350 2240 1380 { lab=agnd}
N 2160 2180 2160 2250 { lab=OUT11}
N 2160 1350 2160 1380 { lab=SouthEast}
N 2640 2180 2640 2250 { lab=OUT12}
N 2800 2180 2800 2250 { lab=OUT13}
N 2960 2180 2960 2250 { lab=OUT14}
N 2560 1350 2560 1380 { lab=avdd}
N 2640 1350 2640 1380 { lab=Vgh}
N 2720 1350 2720 1380 { lab=Vgv}
N 2960 1350 2960 1380 { lab=North}
N 3040 1350 3040 1380 { lab=West}
N 3200 1350 3200 1380 { lab=agnd}
N 3120 2180 3120 2250 { lab=OUT15}
N 3120 1350 3120 1380 { lab=SouthEast}
N 3600 2180 3600 2250 { lab=OUT16}
N 3760 2180 3760 2250 { lab=OUT17}
N 3920 2180 3920 2250 { lab=OUT18}
N 3520 1350 3520 1380 { lab=avdd}
N 3600 1350 3600 1380 { lab=Vgh}
N 3680 1350 3680 1380 { lab=Vgv}
N 3920 1350 3920 1380 { lab=North}
N 4000 1350 4000 1380 { lab=West}
N 4160 1350 4160 1380 { lab=agnd}
N 4080 2180 4080 2250 { lab=OUT19}
N 4080 1350 4080 1380 { lab=SouthEast}
N 4560 2180 4560 2250 { lab=OUT20}
N 4720 2180 4720 2250 { lab=OUT21}
N 4880 2180 4880 2250 { lab=OUT22}
N 4480 1350 4480 1380 { lab=avdd}
N 4560 1350 4560 1380 { lab=Vgh}
N 4640 1350 4640 1380 { lab=Vgv}
N 4880 1350 4880 1380 { lab=North}
N 4960 1350 4960 1380 { lab=West}
N 5120 1350 5120 1380 { lab=agnd}
N 5040 2180 5040 2250 { lab=OUT23}
N 5040 1350 5040 1380 { lab=SouthEast}
N 5520 2180 5520 2250 { lab=OUT24}
N 5680 2180 5680 2250 { lab=OUT25}
N 5840 2180 5840 2250 { lab=OUT26}
N 5440 1350 5440 1380 { lab=avdd}
N 5520 1350 5520 1380 { lab=Vgh}
N 5600 1350 5600 1380 { lab=Vgv}
N 5840 1350 5840 1380 { lab=North}
N 5920 1350 5920 1380 { lab=West}
N 6080 1350 6080 1380 { lab=agnd}
N 6000 2180 6000 2250 { lab=OUT27}
N 6000 1350 6000 1380 { lab=SouthEast}
N 6480 2180 6480 2250 { lab=OUT28}
N 6640 2180 6640 2250 { lab=OUT29}
N 6800 2180 6800 2250 { lab=OUT30}
N 6400 1350 6400 1380 { lab=avdd}
N 6480 1350 6480 1380 { lab=Vgh}
N 6560 1350 6560 1380 { lab=Vgv}
N 6800 1350 6800 1380 { lab=North}
N 6880 1350 6880 1380 { lab=West}
N 7040 1350 7040 1380 { lab=agnd}
N 6960 2180 6960 2250 { lab=OUT15}
N 6960 1350 6960 1380 { lab=SouthEast}
N -400 1540 6320 1540 {}
N -400 1700 6320 1700 {}
N -400 1860 6320 1860 {}
N -400 2020 6320 2020 {}
N -240 3260 -240 3330 { lab=OUT0}
N -80 3260 -80 3330 { lab=OUT1}
N 80 3260 80 3330 { lab=OUT2}
N -320 2430 -320 2460 { lab=avdd}
N -240 2430 -240 2460 { lab=Vgh}
N -160 2430 -160 2460 { lab=Vgv}
N 80 2430 80 2460 { lab=North}
N 160 2430 160 2460 { lab=West}
N 320 2430 320 2460 { lab=agnd}
N 240 3260 240 3330 { lab=OUT3}
N 240 2430 240 2460 { lab=SouthEast}
N -460 3100 -400 3100 { lab=SEL3}
N -460 2940 -400 2940 { lab=SEL2}
N -460 2780 -400 2780 { lab=SEL1}
N -460 2620 -400 2620 { lab=SEL0}
N 720 3260 720 3330 { lab=OUT4}
N 880 3260 880 3330 { lab=OUT5}
N 1040 3260 1040 3330 { lab=OUT6}
N 640 2430 640 2460 { lab=avdd}
N 720 2430 720 2460 { lab=Vgh}
N 800 2430 800 2460 { lab=Vgv}
N 1040 2430 1040 2460 { lab=North}
N 1120 2430 1120 2460 { lab=West}
N 1280 2430 1280 2460 { lab=agnd}
N 1200 3260 1200 3330 { lab=OUT7}
N 1200 2430 1200 2460 { lab=SouthEast}
N 1680 3260 1680 3330 { lab=OUT8}
N 1840 3260 1840 3330 { lab=OUT9}
N 2000 3260 2000 3330 { lab=OUT10}
N 1600 2430 1600 2460 { lab=avdd}
N 1680 2430 1680 2460 { lab=Vgh}
N 1760 2430 1760 2460 { lab=Vgv}
N 2000 2430 2000 2460 { lab=North}
N 2080 2430 2080 2460 { lab=West}
N 2240 2430 2240 2460 { lab=agnd}
N 2160 3260 2160 3330 { lab=OUT11}
N 2160 2430 2160 2460 { lab=SouthEast}
N 2640 3260 2640 3330 { lab=OUT12}
N 2800 3260 2800 3330 { lab=OUT13}
N 2960 3260 2960 3330 { lab=OUT14}
N 2560 2430 2560 2460 { lab=avdd}
N 2640 2430 2640 2460 { lab=Vgh}
N 2720 2430 2720 2460 { lab=Vgv}
N 2960 2430 2960 2460 { lab=North}
N 3040 2430 3040 2460 { lab=West}
N 3200 2430 3200 2460 { lab=agnd}
N 3120 3260 3120 3330 { lab=OUT15}
N 3120 2430 3120 2460 { lab=SouthEast}
N 3600 3260 3600 3330 { lab=OUT16}
N 3760 3260 3760 3330 { lab=OUT17}
N 3920 3260 3920 3330 { lab=OUT18}
N 3520 2430 3520 2460 { lab=avdd}
N 3600 2430 3600 2460 { lab=Vgh}
N 3680 2430 3680 2460 { lab=Vgv}
N 3920 2430 3920 2460 { lab=North}
N 4000 2430 4000 2460 { lab=West}
N 4160 2430 4160 2460 { lab=agnd}
N 4080 3260 4080 3330 { lab=OUT19}
N 4080 2430 4080 2460 { lab=SouthEast}
N 4560 3260 4560 3330 { lab=OUT20}
N 4720 3260 4720 3330 { lab=OUT21}
N 4880 3260 4880 3330 { lab=OUT22}
N 4480 2430 4480 2460 { lab=avdd}
N 4560 2430 4560 2460 { lab=Vgh}
N 4640 2430 4640 2460 { lab=Vgv}
N 4880 2430 4880 2460 { lab=North}
N 4960 2430 4960 2460 { lab=West}
N 5120 2430 5120 2460 { lab=agnd}
N 5040 3260 5040 3330 { lab=OUT23}
N 5040 2430 5040 2460 { lab=SouthEast}
N 5520 3260 5520 3330 { lab=OUT24}
N 5680 3260 5680 3330 { lab=OUT25}
N 5840 3260 5840 3330 { lab=OUT26}
N 5440 2430 5440 2460 { lab=avdd}
N 5520 2430 5520 2460 { lab=Vgh}
N 5600 2430 5600 2460 { lab=Vgv}
N 5840 2430 5840 2460 { lab=North}
N 5920 2430 5920 2460 { lab=West}
N 6080 2430 6080 2460 { lab=agnd}
N 6000 3260 6000 3330 { lab=OUT27}
N 6000 2430 6000 2460 { lab=SouthEast}
N 6480 3260 6480 3330 { lab=OUT28}
N 6640 3260 6640 3330 { lab=OUT29}
N 6800 3260 6800 3330 { lab=OUT30}
N 6400 2430 6400 2460 { lab=avdd}
N 6480 2430 6480 2460 { lab=Vgh}
N 6560 2430 6560 2460 { lab=Vgv}
N 6800 2430 6800 2460 { lab=North}
N 6880 2430 6880 2460 { lab=West}
N 7040 2430 7040 2460 { lab=agnd}
N 6960 3260 6960 3330 { lab=OUT15}
N 6960 2430 6960 2460 { lab=SouthEast}
N -400 2620 6320 2620 {}
N -400 2780 6320 2780 {}
N -400 2940 6320 2940 {}
N -400 3100 6320 3100 {}
N -240 4360 -240 4430 { lab=OUT0}
N -80 4360 -80 4430 { lab=OUT1}
N 80 4360 80 4430 { lab=OUT2}
N -320 3530 -320 3560 { lab=avdd}
N -240 3530 -240 3560 { lab=Vgh}
N -160 3530 -160 3560 { lab=Vgv}
N 80 3530 80 3560 { lab=North}
N 160 3530 160 3560 { lab=West}
N 320 3530 320 3560 { lab=agnd}
N 240 4360 240 4430 { lab=OUT3}
N 240 3530 240 3560 { lab=SouthEast}
N -460 4200 -400 4200 { lab=SEL3}
N -460 4040 -400 4040 { lab=SEL2}
N -460 3880 -400 3880 { lab=SEL1}
N -460 3720 -400 3720 { lab=SEL0}
N 720 4360 720 4430 { lab=OUT4}
N 880 4360 880 4430 { lab=OUT5}
N 1040 4360 1040 4430 { lab=OUT6}
N 640 3530 640 3560 { lab=avdd}
N 720 3530 720 3560 { lab=Vgh}
N 800 3530 800 3560 { lab=Vgv}
N 1040 3530 1040 3560 { lab=North}
N 1120 3530 1120 3560 { lab=West}
N 1280 3530 1280 3560 { lab=agnd}
N 1200 4360 1200 4430 { lab=OUT7}
N 1200 3530 1200 3560 { lab=SouthEast}
N 1680 4360 1680 4430 { lab=OUT8}
N 1840 4360 1840 4430 { lab=OUT9}
N 2000 4360 2000 4430 { lab=OUT10}
N 1600 3530 1600 3560 { lab=avdd}
N 1680 3530 1680 3560 { lab=Vgh}
N 1760 3530 1760 3560 { lab=Vgv}
N 2000 3530 2000 3560 { lab=North}
N 2080 3530 2080 3560 { lab=West}
N 2240 3530 2240 3560 { lab=agnd}
N 2160 4360 2160 4430 { lab=OUT11}
N 2160 3530 2160 3560 { lab=SouthEast}
N 2640 4360 2640 4430 { lab=OUT12}
N 2800 4360 2800 4430 { lab=OUT13}
N 2960 4360 2960 4430 { lab=OUT14}
N 2560 3530 2560 3560 { lab=avdd}
N 2640 3530 2640 3560 { lab=Vgh}
N 2720 3530 2720 3560 { lab=Vgv}
N 2960 3530 2960 3560 { lab=North}
N 3040 3530 3040 3560 { lab=West}
N 3200 3530 3200 3560 { lab=agnd}
N 3120 4360 3120 4430 { lab=OUT15}
N 3120 3530 3120 3560 { lab=SouthEast}
N 3600 4360 3600 4430 { lab=OUT16}
N 3760 4360 3760 4430 { lab=OUT17}
N 3920 4360 3920 4430 { lab=OUT18}
N 3520 3530 3520 3560 { lab=avdd}
N 3600 3530 3600 3560 { lab=Vgh}
N 3680 3530 3680 3560 { lab=Vgv}
N 3920 3530 3920 3560 { lab=North}
N 4000 3530 4000 3560 { lab=West}
N 4160 3530 4160 3560 { lab=agnd}
N 4080 4360 4080 4430 { lab=OUT19}
N 4080 3530 4080 3560 { lab=SouthEast}
N 4560 4360 4560 4430 { lab=OUT20}
N 4720 4360 4720 4430 { lab=OUT21}
N 4880 4360 4880 4430 { lab=OUT22}
N 4480 3530 4480 3560 { lab=avdd}
N 4560 3530 4560 3560 { lab=Vgh}
N 4640 3530 4640 3560 { lab=Vgv}
N 4880 3530 4880 3560 { lab=North}
N 4960 3530 4960 3560 { lab=West}
N 5120 3530 5120 3560 { lab=agnd}
N 5040 4360 5040 4430 { lab=OUT23}
N 5040 3530 5040 3560 { lab=SouthEast}
N 5520 4360 5520 4430 { lab=OUT24}
N 5680 4360 5680 4430 { lab=OUT25}
N 5840 4360 5840 4430 { lab=OUT26}
N 5440 3530 5440 3560 { lab=avdd}
N 5520 3530 5520 3560 { lab=Vgh}
N 5600 3530 5600 3560 { lab=Vgv}
N 5840 3530 5840 3560 { lab=North}
N 5920 3530 5920 3560 { lab=West}
N 6080 3530 6080 3560 { lab=agnd}
N 6000 4360 6000 4430 { lab=OUT27}
N 6000 3530 6000 3560 { lab=SouthEast}
N 6480 4360 6480 4430 { lab=OUT28}
N 6640 4360 6640 4430 { lab=OUT29}
N 6800 4360 6800 4430 { lab=OUT30}
N 6400 3530 6400 3560 { lab=avdd}
N 6480 3530 6480 3560 { lab=Vgh}
N 6560 3530 6560 3560 { lab=Vgv}
N 6800 3530 6800 3560 { lab=North}
N 6880 3530 6880 3560 { lab=West}
N 7040 3530 7040 3560 { lab=agnd}
N 6960 4360 6960 4430 { lab=OUT15}
N 6960 3530 6960 3560 { lab=SouthEast}
N -400 3720 6320 3720 {}
N -400 3880 6320 3880 {}
N -400 4040 6320 4040 {}
N -400 4200 6320 4200 {}
N -240 5460 -240 5530 { lab=OUT0}
N -80 5460 -80 5530 { lab=OUT1}
N 80 5460 80 5530 { lab=OUT2}
N -320 4630 -320 4660 { lab=avdd}
N -240 4630 -240 4660 { lab=Vgh}
N -160 4630 -160 4660 { lab=Vgv}
N 80 4630 80 4660 { lab=North}
N 160 4630 160 4660 { lab=West}
N 320 4630 320 4660 { lab=agnd}
N 240 5460 240 5530 { lab=OUT3}
N 240 4630 240 4660 { lab=SouthEast}
N -460 5300 -400 5300 { lab=SEL3}
N -460 5140 -400 5140 { lab=SEL2}
N -460 4980 -400 4980 { lab=SEL1}
N -460 4820 -400 4820 { lab=SEL0}
N 720 5460 720 5530 { lab=OUT4}
N 880 5460 880 5530 { lab=OUT5}
N 1040 5460 1040 5530 { lab=OUT6}
N 640 4630 640 4660 { lab=avdd}
N 720 4630 720 4660 { lab=Vgh}
N 800 4630 800 4660 { lab=Vgv}
N 1040 4630 1040 4660 { lab=North}
N 1120 4630 1120 4660 { lab=West}
N 1280 4630 1280 4660 { lab=agnd}
N 1200 5460 1200 5530 { lab=OUT7}
N 1200 4630 1200 4660 { lab=SouthEast}
N 1680 5460 1680 5530 { lab=OUT8}
N 1840 5460 1840 5530 { lab=OUT9}
N 2000 5460 2000 5530 { lab=OUT10}
N 1600 4630 1600 4660 { lab=avdd}
N 1680 4630 1680 4660 { lab=Vgh}
N 1760 4630 1760 4660 { lab=Vgv}
N 2000 4630 2000 4660 { lab=North}
N 2080 4630 2080 4660 { lab=West}
N 2240 4630 2240 4660 { lab=agnd}
N 2160 5460 2160 5530 { lab=OUT11}
N 2160 4630 2160 4660 { lab=SouthEast}
N 2640 5460 2640 5530 { lab=OUT12}
N 2800 5460 2800 5530 { lab=OUT13}
N 2960 5460 2960 5530 { lab=OUT14}
N 2560 4630 2560 4660 { lab=avdd}
N 2640 4630 2640 4660 { lab=Vgh}
N 2720 4630 2720 4660 { lab=Vgv}
N 2960 4630 2960 4660 { lab=North}
N 3040 4630 3040 4660 { lab=West}
N 3200 4630 3200 4660 { lab=agnd}
N 3120 5460 3120 5530 { lab=OUT15}
N 3120 4630 3120 4660 { lab=SouthEast}
N 3600 5460 3600 5530 { lab=OUT16}
N 3760 5460 3760 5530 { lab=OUT17}
N 3920 5460 3920 5530 { lab=OUT18}
N 3520 4630 3520 4660 { lab=avdd}
N 3600 4630 3600 4660 { lab=Vgh}
N 3680 4630 3680 4660 { lab=Vgv}
N 3920 4630 3920 4660 { lab=North}
N 4000 4630 4000 4660 { lab=West}
N 4160 4630 4160 4660 { lab=agnd}
N 4080 5460 4080 5530 { lab=OUT19}
N 4080 4630 4080 4660 { lab=SouthEast}
N 4560 5460 4560 5530 { lab=OUT20}
N 4720 5460 4720 5530 { lab=OUT21}
N 4880 5460 4880 5530 { lab=OUT22}
N 4480 4630 4480 4660 { lab=avdd}
N 4560 4630 4560 4660 { lab=Vgh}
N 4640 4630 4640 4660 { lab=Vgv}
N 4880 4630 4880 4660 { lab=North}
N 4960 4630 4960 4660 { lab=West}
N 5120 4630 5120 4660 { lab=agnd}
N 5040 5460 5040 5530 { lab=OUT23}
N 5040 4630 5040 4660 { lab=SouthEast}
N 5520 5460 5520 5530 { lab=OUT24}
N 5680 5460 5680 5530 { lab=OUT25}
N 5840 5460 5840 5530 { lab=OUT26}
N 5440 4630 5440 4660 { lab=avdd}
N 5520 4630 5520 4660 { lab=Vgh}
N 5600 4630 5600 4660 { lab=Vgv}
N 5840 4630 5840 4660 { lab=North}
N 5920 4630 5920 4660 { lab=West}
N 6080 4630 6080 4660 { lab=agnd}
N 6000 5460 6000 5530 { lab=OUT27}
N 6000 4630 6000 4660 { lab=SouthEast}
N 6480 5460 6480 5530 { lab=OUT28}
N 6640 5460 6640 5530 { lab=OUT29}
N 6800 5460 6800 5530 { lab=OUT30}
N 6400 4630 6400 4660 { lab=avdd}
N 6480 4630 6480 4660 { lab=Vgh}
N 6560 4630 6560 4660 { lab=Vgv}
N 6800 4630 6800 4660 { lab=North}
N 6880 4630 6880 4660 { lab=West}
N 7040 4630 7040 4660 { lab=agnd}
N 6960 5460 6960 5530 { lab=OUT15}
N 6960 4630 6960 4660 { lab=SouthEast}
N -400 4820 6320 4820 {}
N -400 4980 6320 4980 {}
N -400 5140 6320 5140 {}
N -400 5300 6320 5300 {}
N -240 6540 -240 6610 { lab=OUT0}
N -80 6540 -80 6610 { lab=OUT1}
N 80 6540 80 6610 { lab=OUT2}
N -320 5710 -320 5740 { lab=avdd}
N -240 5710 -240 5740 { lab=Vgh}
N -160 5710 -160 5740 { lab=Vgv}
N 80 5710 80 5740 { lab=North}
N 160 5710 160 5740 { lab=West}
N 320 5710 320 5740 { lab=agnd}
N 240 6540 240 6610 { lab=OUT3}
N 240 5710 240 5740 { lab=SouthEast}
N -460 6380 -400 6380 { lab=SEL3}
N -460 6220 -400 6220 { lab=SEL2}
N -460 6060 -400 6060 { lab=SEL1}
N -460 5900 -400 5900 { lab=SEL0}
N 720 6540 720 6610 { lab=OUT4}
N 880 6540 880 6610 { lab=OUT5}
N 1040 6540 1040 6610 { lab=OUT6}
N 640 5710 640 5740 { lab=avdd}
N 720 5710 720 5740 { lab=Vgh}
N 800 5710 800 5740 { lab=Vgv}
N 1040 5710 1040 5740 { lab=North}
N 1120 5710 1120 5740 { lab=West}
N 1280 5710 1280 5740 { lab=agnd}
N 1200 6540 1200 6610 { lab=OUT7}
N 1200 5710 1200 5740 { lab=SouthEast}
N 1680 6540 1680 6610 { lab=OUT8}
N 1840 6540 1840 6610 { lab=OUT9}
N 2000 6540 2000 6610 { lab=OUT10}
N 1600 5710 1600 5740 { lab=avdd}
N 1680 5710 1680 5740 { lab=Vgh}
N 1760 5710 1760 5740 { lab=Vgv}
N 2000 5710 2000 5740 { lab=North}
N 2080 5710 2080 5740 { lab=West}
N 2240 5710 2240 5740 { lab=agnd}
N 2160 6540 2160 6610 { lab=OUT11}
N 2160 5710 2160 5740 { lab=SouthEast}
N 2640 6540 2640 6610 { lab=OUT12}
N 2800 6540 2800 6610 { lab=OUT13}
N 2960 6540 2960 6610 { lab=OUT14}
N 2560 5710 2560 5740 { lab=avdd}
N 2640 5710 2640 5740 { lab=Vgh}
N 2720 5710 2720 5740 { lab=Vgv}
N 2960 5710 2960 5740 { lab=North}
N 3040 5710 3040 5740 { lab=West}
N 3200 5710 3200 5740 { lab=agnd}
N 3120 6540 3120 6610 { lab=OUT15}
N 3120 5710 3120 5740 { lab=SouthEast}
N 3600 6540 3600 6610 { lab=OUT16}
N 3760 6540 3760 6610 { lab=OUT17}
N 3920 6540 3920 6610 { lab=OUT18}
N 3520 5710 3520 5740 { lab=avdd}
N 3600 5710 3600 5740 { lab=Vgh}
N 3680 5710 3680 5740 { lab=Vgv}
N 3920 5710 3920 5740 { lab=North}
N 4000 5710 4000 5740 { lab=West}
N 4160 5710 4160 5740 { lab=agnd}
N 4080 6540 4080 6610 { lab=OUT19}
N 4080 5710 4080 5740 { lab=SouthEast}
N 4560 6540 4560 6610 { lab=OUT20}
N 4720 6540 4720 6610 { lab=OUT21}
N 4880 6540 4880 6610 { lab=OUT22}
N 4480 5710 4480 5740 { lab=avdd}
N 4560 5710 4560 5740 { lab=Vgh}
N 4640 5710 4640 5740 { lab=Vgv}
N 4880 5710 4880 5740 { lab=North}
N 4960 5710 4960 5740 { lab=West}
N 5120 5710 5120 5740 { lab=agnd}
N 5040 6540 5040 6610 { lab=OUT23}
N 5040 5710 5040 5740 { lab=SouthEast}
N 5520 6540 5520 6610 { lab=OUT24}
N 5680 6540 5680 6610 { lab=OUT25}
N 5840 6540 5840 6610 { lab=OUT26}
N 5440 5710 5440 5740 { lab=avdd}
N 5520 5710 5520 5740 { lab=Vgh}
N 5600 5710 5600 5740 { lab=Vgv}
N 5840 5710 5840 5740 { lab=North}
N 5920 5710 5920 5740 { lab=West}
N 6080 5710 6080 5740 { lab=agnd}
N 6000 6540 6000 6610 { lab=OUT27}
N 6000 5710 6000 5740 { lab=SouthEast}
N 6480 6540 6480 6610 { lab=OUT28}
N 6640 6540 6640 6610 { lab=OUT29}
N 6800 6540 6800 6610 { lab=OUT30}
N 6400 5710 6400 5740 { lab=avdd}
N 6480 5710 6480 5740 { lab=Vgh}
N 6560 5710 6560 5740 { lab=Vgv}
N 6800 5710 6800 5740 { lab=North}
N 6880 5710 6880 5740 { lab=West}
N 7040 5710 7040 5740 { lab=agnd}
N 6960 6540 6960 6610 { lab=OUT15}
N 6960 5710 6960 5740 { lab=SouthEast}
N -400 5900 6320 5900 {}
N -400 6060 6320 6060 {}
N -400 6220 6320 6220 {}
N -400 6380 6320 6380 {}
N -240 7640 -240 7710 { lab=OUT0}
N -80 7640 -80 7710 { lab=OUT1}
N 80 7640 80 7710 { lab=OUT2}
N -320 6810 -320 6840 { lab=avdd}
N -240 6810 -240 6840 { lab=Vgh}
N -160 6810 -160 6840 { lab=Vgv}
N 80 6810 80 6840 { lab=North}
N 160 6810 160 6840 { lab=West}
N 320 6810 320 6840 { lab=agnd}
N 240 7640 240 7710 { lab=OUT3}
N 240 6810 240 6840 { lab=SouthEast}
N -460 7480 -400 7480 { lab=SEL3}
N -460 7320 -400 7320 { lab=SEL2}
N -460 7160 -400 7160 { lab=SEL1}
N -460 7000 -400 7000 { lab=SEL0}
N 720 7640 720 7710 { lab=OUT4}
N 880 7640 880 7710 { lab=OUT5}
N 1040 7640 1040 7710 { lab=OUT6}
N 640 6810 640 6840 { lab=avdd}
N 720 6810 720 6840 { lab=Vgh}
N 800 6810 800 6840 { lab=Vgv}
N 1040 6810 1040 6840 { lab=North}
N 1120 6810 1120 6840 { lab=West}
N 1280 6810 1280 6840 { lab=agnd}
N 1200 7640 1200 7710 { lab=OUT7}
N 1200 6810 1200 6840 { lab=SouthEast}
N 1680 7640 1680 7710 { lab=OUT8}
N 1840 7640 1840 7710 { lab=OUT9}
N 2000 7640 2000 7710 { lab=OUT10}
N 1600 6810 1600 6840 { lab=avdd}
N 1680 6810 1680 6840 { lab=Vgh}
N 1760 6810 1760 6840 { lab=Vgv}
N 2000 6810 2000 6840 { lab=North}
N 2080 6810 2080 6840 { lab=West}
N 2240 6810 2240 6840 { lab=agnd}
N 2160 7640 2160 7710 { lab=OUT11}
N 2160 6810 2160 6840 { lab=SouthEast}
N 2640 7640 2640 7710 { lab=OUT12}
N 2800 7640 2800 7710 { lab=OUT13}
N 2960 7640 2960 7710 { lab=OUT14}
N 2560 6810 2560 6840 { lab=avdd}
N 2640 6810 2640 6840 { lab=Vgh}
N 2720 6810 2720 6840 { lab=Vgv}
N 2960 6810 2960 6840 { lab=North}
N 3040 6810 3040 6840 { lab=West}
N 3200 6810 3200 6840 { lab=agnd}
N 3120 7640 3120 7710 { lab=OUT15}
N 3120 6810 3120 6840 { lab=SouthEast}
N 3600 7640 3600 7710 { lab=OUT16}
N 3760 7640 3760 7710 { lab=OUT17}
N 3920 7640 3920 7710 { lab=OUT18}
N 3520 6810 3520 6840 { lab=avdd}
N 3600 6810 3600 6840 { lab=Vgh}
N 3680 6810 3680 6840 { lab=Vgv}
N 3920 6810 3920 6840 { lab=North}
N 4000 6810 4000 6840 { lab=West}
N 4160 6810 4160 6840 { lab=agnd}
N 4080 7640 4080 7710 { lab=OUT19}
N 4080 6810 4080 6840 { lab=SouthEast}
N 4560 7640 4560 7710 { lab=OUT20}
N 4720 7640 4720 7710 { lab=OUT21}
N 4880 7640 4880 7710 { lab=OUT22}
N 4480 6810 4480 6840 { lab=avdd}
N 4560 6810 4560 6840 { lab=Vgh}
N 4640 6810 4640 6840 { lab=Vgv}
N 4880 6810 4880 6840 { lab=North}
N 4960 6810 4960 6840 { lab=West}
N 5120 6810 5120 6840 { lab=agnd}
N 5040 7640 5040 7710 { lab=OUT23}
N 5040 6810 5040 6840 { lab=SouthEast}
N 5520 7640 5520 7710 { lab=OUT24}
N 5680 7640 5680 7710 { lab=OUT25}
N 5840 7640 5840 7710 { lab=OUT26}
N 5440 6810 5440 6840 { lab=avdd}
N 5520 6810 5520 6840 { lab=Vgh}
N 5600 6810 5600 6840 { lab=Vgv}
N 5840 6810 5840 6840 { lab=North}
N 5920 6810 5920 6840 { lab=West}
N 6080 6810 6080 6840 { lab=agnd}
N 6000 7640 6000 7710 { lab=OUT27}
N 6000 6810 6000 6840 { lab=SouthEast}
N 6480 7640 6480 7710 { lab=OUT28}
N 6640 7640 6640 7710 { lab=OUT29}
N 6800 7640 6800 7710 { lab=OUT30}
N 6400 6810 6400 6840 { lab=avdd}
N 6480 6810 6480 6840 { lab=Vgh}
N 6560 6810 6560 6840 { lab=Vgv}
N 6800 6810 6800 6840 { lab=North}
N 6880 6810 6880 6840 { lab=West}
N 7040 6810 7040 6840 { lab=agnd}
N 6960 7640 6960 7710 { lab=OUT15}
N 6960 6810 6960 6840 { lab=SouthEast}
N -400 7000 6320 7000 {}
N -400 7160 6320 7160 {}
N -400 7320 6320 7320 {}
N -400 7480 6320 7480 {}
C {devices/netlist.sym} -680 -1260 0 0 {name=SPICE only_toplevel=false value="
.lib /home/sky/sky130A/libs.tech/ngspice/sky130.lib.spice tt
"}
C {devices/iopin.sym} -1070 -840 0 1 {name=p2 lab=avdd}
C {devices/iopin.sym} -1070 -780 0 1 {name=p6 lab=Vgh}
C {devices/iopin.sym} -1070 -760 0 1 {name=p7 lab=Vgv}
C {devices/iopin.sym} -1070 -720 0 1 {name=p8 lab=North}
C {devices/iopin.sym} -790 -440 0 1 {name=p9 lab=OUT0}
C {devices/iopin.sym} -1070 -820 0 1 {name=p10 lab=agnd}
C {devices/iopin.sym} -790 -460 0 1 {name=p12 lab=OUT1}
C {devices/iopin.sym} -790 -480 0 1 {name=p18 lab=OUT2}
C {devices/iopin.sym} -790 -500 0 1 {name=p24 lab=OUT3}
C {devices/iopin.sym} -1070 -700 0 1 {name=p53 lab=West}
C {devices/iopin.sym} -910 -500 0 1 {name=p54 lab=SEL3}
C {devices/iopin.sym} -910 -480 0 1 {name=p60 lab=SEL2}
C {devices/iopin.sym} -910 -460 0 1 {name=p66 lab=SEL1}
C {devices/iopin.sym} -910 -440 0 1 {name=p72 lab=SEL0}
C {devices/lab_pin.sym} 240 70 1 1 {name=l73 sig_type=std_logic lab=OUT3}
C {devices/lab_pin.sym} 80 70 1 1 {name=l74 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} -80 70 1 1 {name=l75 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} -240 70 1 1 {name=l81 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} -320 -830 1 0 {name=l82 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -240 -830 1 0 {name=l83 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} -160 -830 1 0 {name=l84 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 320 -830 1 0 {name=l86 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 160 -830 1 0 {name=l87 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 80 -830 1 0 {name=l26 sig_type=std_logic lab=North}
C {devices/iopin.sym} -1070 -680 0 1 {name=p1 lab=SouthEast}
C {HW4_RAM_readout/pixel_4x4.sym} 20 -420 0 0 {name=X17}
C {devices/lab_pin.sym} 240 -830 1 0 {name=l28 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} -460 -160 0 0 {name=l29 sig_type=std_logic lab=SEL3}
C {devices/lab_pin.sym} -460 -320 0 0 {name=l30 sig_type=std_logic lab=SEL2}
C {devices/lab_pin.sym} -460 -480 0 0 {name=l31 sig_type=std_logic lab=SEL1}
C {devices/lab_pin.sym} -460 -640 0 0 {name=l32 sig_type=std_logic lab=SEL0}
C {devices/lab_pin.sym} 1200 70 1 1 {name=l1 sig_type=std_logic lab=OUT7}
C {devices/lab_pin.sym} 1040 70 1 1 {name=l2 sig_type=std_logic lab=OUT6}
C {devices/lab_pin.sym} 880 70 1 1 {name=l3 sig_type=std_logic lab=OUT5}
C {devices/lab_pin.sym} 720 70 1 1 {name=l4 sig_type=std_logic lab=OUT4}
C {devices/lab_pin.sym} 640 -830 1 0 {name=l5 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 720 -830 1 0 {name=l6 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 800 -830 1 0 {name=l7 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 1280 -830 1 0 {name=l8 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 1120 -830 1 0 {name=l9 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 1040 -830 1 0 {name=l10 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 980 -420 0 0 {name=X1}
C {devices/lab_pin.sym} 1200 -830 1 0 {name=l11 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 500 -160 0 0 {name=l12 sig_type=std_logic lab=SEL3}
C {devices/lab_pin.sym} 500 -320 0 0 {name=l13 sig_type=std_logic lab=SEL2}
C {devices/lab_pin.sym} 500 -480 0 0 {name=l14 sig_type=std_logic lab=SEL1}
C {devices/lab_pin.sym} 500 -640 0 0 {name=l15 sig_type=std_logic lab=SEL0}
C {devices/lab_pin.sym} 2160 70 1 1 {name=l16 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 2000 70 1 1 {name=l17 sig_type=std_logic lab=OUT10}
C {devices/lab_pin.sym} 1840 70 1 1 {name=l18 sig_type=std_logic lab=OUT9}
C {devices/lab_pin.sym} 1680 70 1 1 {name=l19 sig_type=std_logic lab=OUT8}
C {devices/lab_pin.sym} 1600 -830 1 0 {name=l20 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1680 -830 1 0 {name=l21 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 1760 -830 1 0 {name=l22 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 2240 -830 1 0 {name=l23 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 2080 -830 1 0 {name=l24 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2000 -830 1 0 {name=l25 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 1940 -420 0 0 {name=X2}
C {devices/lab_pin.sym} 2160 -830 1 0 {name=l27 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 1460 -160 0 0 {name=l33 sig_type=std_logic lab=SEL3}
C {devices/lab_pin.sym} 1460 -320 0 0 {name=l34 sig_type=std_logic lab=SEL2}
C {devices/lab_pin.sym} 1460 -480 0 0 {name=l35 sig_type=std_logic lab=SEL1}
C {devices/lab_pin.sym} 1460 -640 0 0 {name=l36 sig_type=std_logic lab=SEL0}
C {devices/lab_pin.sym} 3120 70 1 1 {name=l37 sig_type=std_logic lab=OUT15}
C {devices/lab_pin.sym} 2960 70 1 1 {name=l38 sig_type=std_logic lab=OUT14}
C {devices/lab_pin.sym} 2800 70 1 1 {name=l39 sig_type=std_logic lab=OUT13}
C {devices/lab_pin.sym} 2640 70 1 1 {name=l40 sig_type=std_logic lab=OUT12}
C {devices/lab_pin.sym} 2560 -830 1 0 {name=l41 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2640 -830 1 0 {name=l42 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 2720 -830 1 0 {name=l43 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 3200 -830 1 0 {name=l44 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 3040 -830 1 0 {name=l45 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2960 -830 1 0 {name=l46 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 2900 -420 0 0 {name=X3}
C {devices/lab_pin.sym} 3120 -830 1 0 {name=l47 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 2420 -160 0 0 {name=l48 sig_type=std_logic lab=SEL3}
C {devices/lab_pin.sym} 2420 -320 0 0 {name=l49 sig_type=std_logic lab=SEL2}
C {devices/lab_pin.sym} 2420 -480 0 0 {name=l50 sig_type=std_logic lab=SEL1}
C {devices/lab_pin.sym} 2420 -640 0 0 {name=l51 sig_type=std_logic lab=SEL0}
C {devices/lab_pin.sym} 4080 70 1 1 {name=l52 sig_type=std_logic lab=OUT19}
C {devices/lab_pin.sym} 3920 70 1 1 {name=l53 sig_type=std_logic lab=OUT18}
C {devices/lab_pin.sym} 3760 70 1 1 {name=l54 sig_type=std_logic lab=OUT17}
C {devices/lab_pin.sym} 3600 70 1 1 {name=l55 sig_type=std_logic lab=OUT16}
C {devices/lab_pin.sym} 3520 -830 1 0 {name=l56 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3600 -830 1 0 {name=l57 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 3680 -830 1 0 {name=l58 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 4160 -830 1 0 {name=l59 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4000 -830 1 0 {name=l60 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 3920 -830 1 0 {name=l61 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 3860 -420 0 0 {name=X4}
C {devices/lab_pin.sym} 4080 -830 1 0 {name=l62 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 3380 -160 0 0 {name=l63 sig_type=std_logic lab=SEL3}
C {devices/lab_pin.sym} 3380 -320 0 0 {name=l64 sig_type=std_logic lab=SEL2}
C {devices/lab_pin.sym} 3380 -480 0 0 {name=l65 sig_type=std_logic lab=SEL1}
C {devices/lab_pin.sym} 3380 -640 0 0 {name=l66 sig_type=std_logic lab=SEL0}
C {devices/lab_pin.sym} 5040 70 1 1 {name=l67 sig_type=std_logic lab=OUT23}
C {devices/lab_pin.sym} 4880 70 1 1 {name=l68 sig_type=std_logic lab=OUT22}
C {devices/lab_pin.sym} 4720 70 1 1 {name=l69 sig_type=std_logic lab=OUT21}
C {devices/lab_pin.sym} 4560 70 1 1 {name=l70 sig_type=std_logic lab=OUT20}
C {devices/lab_pin.sym} 4480 -830 1 0 {name=l71 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4560 -830 1 0 {name=l72 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 4640 -830 1 0 {name=l76 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 5120 -830 1 0 {name=l77 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4960 -830 1 0 {name=l78 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 4880 -830 1 0 {name=l79 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 4820 -420 0 0 {name=X5}
C {devices/lab_pin.sym} 5040 -830 1 0 {name=l80 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 4340 -160 0 0 {name=l85 sig_type=std_logic lab=SEL3}
C {devices/lab_pin.sym} 4340 -320 0 0 {name=l88 sig_type=std_logic lab=SEL2}
C {devices/lab_pin.sym} 4340 -480 0 0 {name=l89 sig_type=std_logic lab=SEL1}
C {devices/lab_pin.sym} 4340 -640 0 0 {name=l90 sig_type=std_logic lab=SEL0}
C {devices/lab_pin.sym} 6000 70 1 1 {name=l91 sig_type=std_logic lab=OUT27}
C {devices/lab_pin.sym} 5840 70 1 1 {name=l92 sig_type=std_logic lab=OUT26}
C {devices/lab_pin.sym} 5680 70 1 1 {name=l93 sig_type=std_logic lab=OUT25}
C {devices/lab_pin.sym} 5520 70 1 1 {name=l94 sig_type=std_logic lab=OUT24}
C {devices/lab_pin.sym} 5440 -830 1 0 {name=l95 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 5520 -830 1 0 {name=l96 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 5600 -830 1 0 {name=l97 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 6080 -830 1 0 {name=l98 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 5920 -830 1 0 {name=l99 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 5840 -830 1 0 {name=l100 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 5780 -420 0 0 {name=X6}
C {devices/lab_pin.sym} 6000 -830 1 0 {name=l101 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 5300 -160 0 0 {name=l102 sig_type=std_logic lab=SEL3}
C {devices/lab_pin.sym} 5300 -320 0 0 {name=l103 sig_type=std_logic lab=SEL2}
C {devices/lab_pin.sym} 5300 -480 0 0 {name=l104 sig_type=std_logic lab=SEL1}
C {devices/lab_pin.sym} 5300 -640 0 0 {name=l105 sig_type=std_logic lab=SEL0}
C {devices/lab_pin.sym} 6960 70 1 1 {name=l106 sig_type=std_logic lab=OUT31}
C {devices/lab_pin.sym} 6800 70 1 1 {name=l107 sig_type=std_logic lab=OUT30}
C {devices/lab_pin.sym} 6640 70 1 1 {name=l108 sig_type=std_logic lab=OUT29}
C {devices/lab_pin.sym} 6480 70 1 1 {name=l109 sig_type=std_logic lab=OUT28}
C {devices/lab_pin.sym} 6400 -830 1 0 {name=l110 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 6480 -830 1 0 {name=l111 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 6560 -830 1 0 {name=l112 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 7040 -830 1 0 {name=l113 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 6880 -830 1 0 {name=l114 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 6800 -830 1 0 {name=l115 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 6740 -420 0 0 {name=X7}
C {devices/lab_pin.sym} 6960 -830 1 0 {name=l116 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6260 -160 0 0 {name=l117 sig_type=std_logic lab=SEL3}
C {devices/lab_pin.sym} 6260 -320 0 0 {name=l118 sig_type=std_logic lab=SEL2}
C {devices/lab_pin.sym} 6260 -480 0 0 {name=l119 sig_type=std_logic lab=SEL1}
C {devices/lab_pin.sym} 6260 -640 0 0 {name=l120 sig_type=std_logic lab=SEL0}
C {devices/lab_pin.sym} 240 1150 1 1 {name=l121 sig_type=std_logic lab=OUT3}
C {devices/lab_pin.sym} 80 1150 1 1 {name=l122 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} -80 1150 1 1 {name=l123 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} -240 1150 1 1 {name=l124 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} -320 250 1 0 {name=l125 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -240 250 1 0 {name=l126 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} -160 250 1 0 {name=l127 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 320 250 1 0 {name=l128 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 160 250 1 0 {name=l129 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 80 250 1 0 {name=l130 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 20 660 0 0 {name=X8}
C {devices/lab_pin.sym} 240 250 1 0 {name=l131 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} -460 920 0 0 {name=l132 sig_type=std_logic lab=SEL7}
C {devices/lab_pin.sym} -460 760 0 0 {name=l133 sig_type=std_logic lab=SEL6}
C {devices/lab_pin.sym} -460 600 0 0 {name=l134 sig_type=std_logic lab=SEL5}
C {devices/lab_pin.sym} -460 440 0 0 {name=l135 sig_type=std_logic lab=SEL4}
C {devices/lab_pin.sym} 1200 1150 1 1 {name=l136 sig_type=std_logic lab=OUT7}
C {devices/lab_pin.sym} 1040 1150 1 1 {name=l137 sig_type=std_logic lab=OUT6}
C {devices/lab_pin.sym} 880 1150 1 1 {name=l138 sig_type=std_logic lab=OUT5}
C {devices/lab_pin.sym} 720 1150 1 1 {name=l139 sig_type=std_logic lab=OUT4}
C {devices/lab_pin.sym} 640 250 1 0 {name=l140 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 720 250 1 0 {name=l141 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 800 250 1 0 {name=l142 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 1280 250 1 0 {name=l143 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 1120 250 1 0 {name=l144 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 1040 250 1 0 {name=l145 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 980 660 0 0 {name=X9}
C {devices/lab_pin.sym} 1200 250 1 0 {name=l146 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 2160 1150 1 1 {name=l151 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 2000 1150 1 1 {name=l152 sig_type=std_logic lab=OUT10}
C {devices/lab_pin.sym} 1840 1150 1 1 {name=l153 sig_type=std_logic lab=OUT9}
C {devices/lab_pin.sym} 1680 1150 1 1 {name=l154 sig_type=std_logic lab=OUT8}
C {devices/lab_pin.sym} 1600 250 1 0 {name=l155 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1680 250 1 0 {name=l156 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 1760 250 1 0 {name=l157 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 2240 250 1 0 {name=l158 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 2080 250 1 0 {name=l159 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2000 250 1 0 {name=l160 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 1940 660 0 0 {name=X10}
C {devices/lab_pin.sym} 2160 250 1 0 {name=l161 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 3120 1150 1 1 {name=l166 sig_type=std_logic lab=OUT15}
C {devices/lab_pin.sym} 2960 1150 1 1 {name=l167 sig_type=std_logic lab=OUT14}
C {devices/lab_pin.sym} 2800 1150 1 1 {name=l168 sig_type=std_logic lab=OUT13}
C {devices/lab_pin.sym} 2640 1150 1 1 {name=l169 sig_type=std_logic lab=OUT12}
C {devices/lab_pin.sym} 2560 250 1 0 {name=l170 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2640 250 1 0 {name=l171 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 2720 250 1 0 {name=l172 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 3200 250 1 0 {name=l173 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 3040 250 1 0 {name=l174 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2960 250 1 0 {name=l175 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 2900 660 0 0 {name=X11}
C {devices/lab_pin.sym} 3120 250 1 0 {name=l176 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 4080 1150 1 1 {name=l181 sig_type=std_logic lab=OUT19}
C {devices/lab_pin.sym} 3920 1150 1 1 {name=l182 sig_type=std_logic lab=OUT18}
C {devices/lab_pin.sym} 3760 1150 1 1 {name=l183 sig_type=std_logic lab=OUT17}
C {devices/lab_pin.sym} 3600 1150 1 1 {name=l184 sig_type=std_logic lab=OUT16}
C {devices/lab_pin.sym} 3520 250 1 0 {name=l185 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3600 250 1 0 {name=l186 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 3680 250 1 0 {name=l187 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 4160 250 1 0 {name=l188 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4000 250 1 0 {name=l189 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 3920 250 1 0 {name=l190 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 3860 660 0 0 {name=X12}
C {devices/lab_pin.sym} 4080 250 1 0 {name=l191 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 5040 1150 1 1 {name=l196 sig_type=std_logic lab=OUT23}
C {devices/lab_pin.sym} 4880 1150 1 1 {name=l197 sig_type=std_logic lab=OUT22}
C {devices/lab_pin.sym} 4720 1150 1 1 {name=l198 sig_type=std_logic lab=OUT21}
C {devices/lab_pin.sym} 4560 1150 1 1 {name=l199 sig_type=std_logic lab=OUT20}
C {devices/lab_pin.sym} 4480 250 1 0 {name=l200 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4560 250 1 0 {name=l201 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 4640 250 1 0 {name=l202 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 5120 250 1 0 {name=l203 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4960 250 1 0 {name=l204 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 4880 250 1 0 {name=l205 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 4820 660 0 0 {name=X13}
C {devices/lab_pin.sym} 5040 250 1 0 {name=l206 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6000 1150 1 1 {name=l211 sig_type=std_logic lab=OUT27}
C {devices/lab_pin.sym} 5840 1150 1 1 {name=l212 sig_type=std_logic lab=OUT26}
C {devices/lab_pin.sym} 5680 1150 1 1 {name=l213 sig_type=std_logic lab=OUT25}
C {devices/lab_pin.sym} 5520 1150 1 1 {name=l214 sig_type=std_logic lab=OUT24}
C {devices/lab_pin.sym} 5440 250 1 0 {name=l215 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 5520 250 1 0 {name=l216 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 5600 250 1 0 {name=l217 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 6080 250 1 0 {name=l218 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 5920 250 1 0 {name=l219 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 5840 250 1 0 {name=l220 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 5780 660 0 0 {name=X14}
C {devices/lab_pin.sym} 6000 250 1 0 {name=l221 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6960 1150 1 1 {name=l226 sig_type=std_logic lab=OUT31}
C {devices/lab_pin.sym} 6800 1150 1 1 {name=l227 sig_type=std_logic lab=OUT30}
C {devices/lab_pin.sym} 6640 1150 1 1 {name=l228 sig_type=std_logic lab=OUT29}
C {devices/lab_pin.sym} 6480 1150 1 1 {name=l229 sig_type=std_logic lab=OUT28}
C {devices/lab_pin.sym} 6400 250 1 0 {name=l230 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 6480 250 1 0 {name=l231 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 6560 250 1 0 {name=l232 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 7040 250 1 0 {name=l233 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 6880 250 1 0 {name=l234 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 6800 250 1 0 {name=l235 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 6740 660 0 0 {name=X15}
C {devices/lab_pin.sym} 6960 250 1 0 {name=l236 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 240 2250 1 1 {name=l147 sig_type=std_logic lab=OUT3}
C {devices/lab_pin.sym} 80 2250 1 1 {name=l148 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} -80 2250 1 1 {name=l149 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} -240 2250 1 1 {name=l150 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} -320 1350 1 0 {name=l162 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -240 1350 1 0 {name=l163 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} -160 1350 1 0 {name=l164 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 320 1350 1 0 {name=l165 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 160 1350 1 0 {name=l177 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 80 1350 1 0 {name=l178 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 20 1760 0 0 {name=X16}
C {devices/lab_pin.sym} 240 1350 1 0 {name=l179 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} -460 2020 0 0 {name=l180 sig_type=std_logic lab=SEL11}
C {devices/lab_pin.sym} -460 1860 0 0 {name=l192 sig_type=std_logic lab=SEL10}
C {devices/lab_pin.sym} -460 1700 0 0 {name=l193 sig_type=std_logic lab=SEL9}
C {devices/lab_pin.sym} -460 1540 0 0 {name=l194 sig_type=std_logic lab=SEL8}
C {devices/lab_pin.sym} 1200 2250 1 1 {name=l195 sig_type=std_logic lab=OUT7}
C {devices/lab_pin.sym} 1040 2250 1 1 {name=l207 sig_type=std_logic lab=OUT6}
C {devices/lab_pin.sym} 880 2250 1 1 {name=l208 sig_type=std_logic lab=OUT5}
C {devices/lab_pin.sym} 720 2250 1 1 {name=l209 sig_type=std_logic lab=OUT4}
C {devices/lab_pin.sym} 640 1350 1 0 {name=l210 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 720 1350 1 0 {name=l222 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 800 1350 1 0 {name=l223 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 1280 1350 1 0 {name=l224 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 1120 1350 1 0 {name=l225 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 1040 1350 1 0 {name=l237 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 980 1760 0 0 {name=X18}
C {devices/lab_pin.sym} 1200 1350 1 0 {name=l238 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 2160 2250 1 1 {name=l239 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 2000 2250 1 1 {name=l240 sig_type=std_logic lab=OUT10}
C {devices/lab_pin.sym} 1840 2250 1 1 {name=l241 sig_type=std_logic lab=OUT9}
C {devices/lab_pin.sym} 1680 2250 1 1 {name=l242 sig_type=std_logic lab=OUT8}
C {devices/lab_pin.sym} 1600 1350 1 0 {name=l243 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1680 1350 1 0 {name=l244 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 1760 1350 1 0 {name=l245 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 2240 1350 1 0 {name=l246 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 2080 1350 1 0 {name=l247 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2000 1350 1 0 {name=l248 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 1940 1760 0 0 {name=X19}
C {devices/lab_pin.sym} 2160 1350 1 0 {name=l249 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 3120 2250 1 1 {name=l250 sig_type=std_logic lab=OUT15}
C {devices/lab_pin.sym} 2960 2250 1 1 {name=l251 sig_type=std_logic lab=OUT14}
C {devices/lab_pin.sym} 2800 2250 1 1 {name=l252 sig_type=std_logic lab=OUT13}
C {devices/lab_pin.sym} 2640 2250 1 1 {name=l253 sig_type=std_logic lab=OUT12}
C {devices/lab_pin.sym} 2560 1350 1 0 {name=l254 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2640 1350 1 0 {name=l255 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 2720 1350 1 0 {name=l256 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 3200 1350 1 0 {name=l257 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 3040 1350 1 0 {name=l258 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2960 1350 1 0 {name=l259 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 2900 1760 0 0 {name=X20}
C {devices/lab_pin.sym} 3120 1350 1 0 {name=l260 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 4080 2250 1 1 {name=l261 sig_type=std_logic lab=OUT19}
C {devices/lab_pin.sym} 3920 2250 1 1 {name=l262 sig_type=std_logic lab=OUT18}
C {devices/lab_pin.sym} 3760 2250 1 1 {name=l263 sig_type=std_logic lab=OUT17}
C {devices/lab_pin.sym} 3600 2250 1 1 {name=l264 sig_type=std_logic lab=OUT16}
C {devices/lab_pin.sym} 3520 1350 1 0 {name=l265 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3600 1350 1 0 {name=l266 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 3680 1350 1 0 {name=l267 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 4160 1350 1 0 {name=l268 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4000 1350 1 0 {name=l269 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 3920 1350 1 0 {name=l270 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 3860 1760 0 0 {name=X21}
C {devices/lab_pin.sym} 4080 1350 1 0 {name=l271 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 5040 2250 1 1 {name=l272 sig_type=std_logic lab=OUT23}
C {devices/lab_pin.sym} 4880 2250 1 1 {name=l273 sig_type=std_logic lab=OUT22}
C {devices/lab_pin.sym} 4720 2250 1 1 {name=l274 sig_type=std_logic lab=OUT21}
C {devices/lab_pin.sym} 4560 2250 1 1 {name=l275 sig_type=std_logic lab=OUT20}
C {devices/lab_pin.sym} 4480 1350 1 0 {name=l276 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4560 1350 1 0 {name=l277 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 4640 1350 1 0 {name=l278 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 5120 1350 1 0 {name=l279 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4960 1350 1 0 {name=l280 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 4880 1350 1 0 {name=l281 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 4820 1760 0 0 {name=X22}
C {devices/lab_pin.sym} 5040 1350 1 0 {name=l282 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6000 2250 1 1 {name=l283 sig_type=std_logic lab=OUT27}
C {devices/lab_pin.sym} 5840 2250 1 1 {name=l284 sig_type=std_logic lab=OUT26}
C {devices/lab_pin.sym} 5680 2250 1 1 {name=l285 sig_type=std_logic lab=OUT25}
C {devices/lab_pin.sym} 5520 2250 1 1 {name=l286 sig_type=std_logic lab=OUT24}
C {devices/lab_pin.sym} 5440 1350 1 0 {name=l287 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 5520 1350 1 0 {name=l288 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 5600 1350 1 0 {name=l289 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 6080 1350 1 0 {name=l290 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 5920 1350 1 0 {name=l291 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 5840 1350 1 0 {name=l292 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 5780 1760 0 0 {name=X23}
C {devices/lab_pin.sym} 6000 1350 1 0 {name=l293 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6960 2250 1 1 {name=l294 sig_type=std_logic lab=OUT31}
C {devices/lab_pin.sym} 6800 2250 1 1 {name=l295 sig_type=std_logic lab=OUT30}
C {devices/lab_pin.sym} 6640 2250 1 1 {name=l296 sig_type=std_logic lab=OUT29}
C {devices/lab_pin.sym} 6480 2250 1 1 {name=l297 sig_type=std_logic lab=OUT28}
C {devices/lab_pin.sym} 6400 1350 1 0 {name=l298 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 6480 1350 1 0 {name=l299 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 6560 1350 1 0 {name=l300 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 7040 1350 1 0 {name=l301 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 6880 1350 1 0 {name=l302 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 6800 1350 1 0 {name=l303 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 6740 1760 0 0 {name=X24}
C {devices/lab_pin.sym} 6960 1350 1 0 {name=l304 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 240 3330 1 1 {name=l305 sig_type=std_logic lab=OUT3}
C {devices/lab_pin.sym} 80 3330 1 1 {name=l306 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} -80 3330 1 1 {name=l307 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} -240 3330 1 1 {name=l308 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} -320 2430 1 0 {name=l309 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -240 2430 1 0 {name=l310 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} -160 2430 1 0 {name=l311 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 320 2430 1 0 {name=l312 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 160 2430 1 0 {name=l313 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 80 2430 1 0 {name=l314 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 20 2840 0 0 {name=X25}
C {devices/lab_pin.sym} 240 2430 1 0 {name=l315 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} -460 3100 0 0 {name=l316 sig_type=std_logic lab=SEL15}
C {devices/lab_pin.sym} -460 2940 0 0 {name=l317 sig_type=std_logic lab=SEL14}
C {devices/lab_pin.sym} -460 2780 0 0 {name=l318 sig_type=std_logic lab=SEL13}
C {devices/lab_pin.sym} -460 2620 0 0 {name=l319 sig_type=std_logic lab=SEL12}
C {devices/lab_pin.sym} 1200 3330 1 1 {name=l320 sig_type=std_logic lab=OUT7}
C {devices/lab_pin.sym} 1040 3330 1 1 {name=l321 sig_type=std_logic lab=OUT6}
C {devices/lab_pin.sym} 880 3330 1 1 {name=l322 sig_type=std_logic lab=OUT5}
C {devices/lab_pin.sym} 720 3330 1 1 {name=l323 sig_type=std_logic lab=OUT4}
C {devices/lab_pin.sym} 640 2430 1 0 {name=l324 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 720 2430 1 0 {name=l325 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 800 2430 1 0 {name=l326 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 1280 2430 1 0 {name=l327 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 1120 2430 1 0 {name=l328 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 1040 2430 1 0 {name=l329 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 980 2840 0 0 {name=X26}
C {devices/lab_pin.sym} 1200 2430 1 0 {name=l330 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 2160 3330 1 1 {name=l331 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 2000 3330 1 1 {name=l332 sig_type=std_logic lab=OUT10}
C {devices/lab_pin.sym} 1840 3330 1 1 {name=l333 sig_type=std_logic lab=OUT9}
C {devices/lab_pin.sym} 1680 3330 1 1 {name=l334 sig_type=std_logic lab=OUT8}
C {devices/lab_pin.sym} 1600 2430 1 0 {name=l335 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1680 2430 1 0 {name=l336 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 1760 2430 1 0 {name=l337 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 2240 2430 1 0 {name=l338 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 2080 2430 1 0 {name=l339 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2000 2430 1 0 {name=l340 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 1940 2840 0 0 {name=X27}
C {devices/lab_pin.sym} 2160 2430 1 0 {name=l341 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 3120 3330 1 1 {name=l342 sig_type=std_logic lab=OUT15}
C {devices/lab_pin.sym} 2960 3330 1 1 {name=l343 sig_type=std_logic lab=OUT14}
C {devices/lab_pin.sym} 2800 3330 1 1 {name=l344 sig_type=std_logic lab=OUT13}
C {devices/lab_pin.sym} 2640 3330 1 1 {name=l345 sig_type=std_logic lab=OUT12}
C {devices/lab_pin.sym} 2560 2430 1 0 {name=l346 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2640 2430 1 0 {name=l347 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 2720 2430 1 0 {name=l348 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 3200 2430 1 0 {name=l349 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 3040 2430 1 0 {name=l350 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2960 2430 1 0 {name=l351 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 2900 2840 0 0 {name=X28}
C {devices/lab_pin.sym} 3120 2430 1 0 {name=l352 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 4080 3330 1 1 {name=l353 sig_type=std_logic lab=OUT19}
C {devices/lab_pin.sym} 3920 3330 1 1 {name=l354 sig_type=std_logic lab=OUT18}
C {devices/lab_pin.sym} 3760 3330 1 1 {name=l355 sig_type=std_logic lab=OUT17}
C {devices/lab_pin.sym} 3600 3330 1 1 {name=l356 sig_type=std_logic lab=OUT16}
C {devices/lab_pin.sym} 3520 2430 1 0 {name=l357 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3600 2430 1 0 {name=l358 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 3680 2430 1 0 {name=l359 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 4160 2430 1 0 {name=l360 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4000 2430 1 0 {name=l361 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 3920 2430 1 0 {name=l362 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 3860 2840 0 0 {name=X29}
C {devices/lab_pin.sym} 4080 2430 1 0 {name=l363 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 5040 3330 1 1 {name=l364 sig_type=std_logic lab=OUT23}
C {devices/lab_pin.sym} 4880 3330 1 1 {name=l365 sig_type=std_logic lab=OUT22}
C {devices/lab_pin.sym} 4720 3330 1 1 {name=l366 sig_type=std_logic lab=OUT21}
C {devices/lab_pin.sym} 4560 3330 1 1 {name=l367 sig_type=std_logic lab=OUT20}
C {devices/lab_pin.sym} 4480 2430 1 0 {name=l368 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4560 2430 1 0 {name=l369 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 4640 2430 1 0 {name=l370 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 5120 2430 1 0 {name=l371 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4960 2430 1 0 {name=l372 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 4880 2430 1 0 {name=l373 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 4820 2840 0 0 {name=X30}
C {devices/lab_pin.sym} 5040 2430 1 0 {name=l374 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6000 3330 1 1 {name=l375 sig_type=std_logic lab=OUT27}
C {devices/lab_pin.sym} 5840 3330 1 1 {name=l376 sig_type=std_logic lab=OUT26}
C {devices/lab_pin.sym} 5680 3330 1 1 {name=l377 sig_type=std_logic lab=OUT25}
C {devices/lab_pin.sym} 5520 3330 1 1 {name=l378 sig_type=std_logic lab=OUT24}
C {devices/lab_pin.sym} 5440 2430 1 0 {name=l379 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 5520 2430 1 0 {name=l380 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 5600 2430 1 0 {name=l381 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 6080 2430 1 0 {name=l382 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 5920 2430 1 0 {name=l383 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 5840 2430 1 0 {name=l384 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 5780 2840 0 0 {name=X31}
C {devices/lab_pin.sym} 6000 2430 1 0 {name=l385 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6960 3330 1 1 {name=l386 sig_type=std_logic lab=OUT31}
C {devices/lab_pin.sym} 6800 3330 1 1 {name=l387 sig_type=std_logic lab=OUT30}
C {devices/lab_pin.sym} 6640 3330 1 1 {name=l388 sig_type=std_logic lab=OUT29}
C {devices/lab_pin.sym} 6480 3330 1 1 {name=l389 sig_type=std_logic lab=OUT28}
C {devices/lab_pin.sym} 6400 2430 1 0 {name=l390 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 6480 2430 1 0 {name=l391 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 6560 2430 1 0 {name=l392 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 7040 2430 1 0 {name=l393 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 6880 2430 1 0 {name=l394 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 6800 2430 1 0 {name=l395 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 6740 2840 0 0 {name=X32}
C {devices/lab_pin.sym} 6960 2430 1 0 {name=l396 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 240 4430 1 1 {name=l397 sig_type=std_logic lab=OUT3}
C {devices/lab_pin.sym} 80 4430 1 1 {name=l398 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} -80 4430 1 1 {name=l399 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} -240 4430 1 1 {name=l400 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} -320 3530 1 0 {name=l401 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -240 3530 1 0 {name=l402 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} -160 3530 1 0 {name=l403 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 320 3530 1 0 {name=l404 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 160 3530 1 0 {name=l405 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 80 3530 1 0 {name=l406 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 20 3940 0 0 {name=X33}
C {devices/lab_pin.sym} 240 3530 1 0 {name=l407 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} -460 4200 0 0 {name=l408 sig_type=std_logic lab=SEL19}
C {devices/lab_pin.sym} -460 4040 0 0 {name=l409 sig_type=std_logic lab=SEL18}
C {devices/lab_pin.sym} -460 3880 0 0 {name=l410 sig_type=std_logic lab=SEL17}
C {devices/lab_pin.sym} -460 3720 0 0 {name=l411 sig_type=std_logic lab=SEL16}
C {devices/lab_pin.sym} 1200 4430 1 1 {name=l412 sig_type=std_logic lab=OUT7}
C {devices/lab_pin.sym} 1040 4430 1 1 {name=l413 sig_type=std_logic lab=OUT6}
C {devices/lab_pin.sym} 880 4430 1 1 {name=l414 sig_type=std_logic lab=OUT5}
C {devices/lab_pin.sym} 720 4430 1 1 {name=l415 sig_type=std_logic lab=OUT4}
C {devices/lab_pin.sym} 640 3530 1 0 {name=l416 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 720 3530 1 0 {name=l417 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 800 3530 1 0 {name=l418 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 1280 3530 1 0 {name=l419 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 1120 3530 1 0 {name=l420 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 1040 3530 1 0 {name=l421 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 980 3940 0 0 {name=X34}
C {devices/lab_pin.sym} 1200 3530 1 0 {name=l422 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 2160 4430 1 1 {name=l423 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 2000 4430 1 1 {name=l424 sig_type=std_logic lab=OUT10}
C {devices/lab_pin.sym} 1840 4430 1 1 {name=l425 sig_type=std_logic lab=OUT9}
C {devices/lab_pin.sym} 1680 4430 1 1 {name=l426 sig_type=std_logic lab=OUT8}
C {devices/lab_pin.sym} 1600 3530 1 0 {name=l427 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1680 3530 1 0 {name=l428 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 1760 3530 1 0 {name=l429 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 2240 3530 1 0 {name=l430 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 2080 3530 1 0 {name=l431 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2000 3530 1 0 {name=l432 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 1940 3940 0 0 {name=X35}
C {devices/lab_pin.sym} 2160 3530 1 0 {name=l433 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 3120 4430 1 1 {name=l434 sig_type=std_logic lab=OUT15}
C {devices/lab_pin.sym} 2960 4430 1 1 {name=l435 sig_type=std_logic lab=OUT14}
C {devices/lab_pin.sym} 2800 4430 1 1 {name=l436 sig_type=std_logic lab=OUT13}
C {devices/lab_pin.sym} 2640 4430 1 1 {name=l437 sig_type=std_logic lab=OUT12}
C {devices/lab_pin.sym} 2560 3530 1 0 {name=l438 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2640 3530 1 0 {name=l439 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 2720 3530 1 0 {name=l440 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 3200 3530 1 0 {name=l441 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 3040 3530 1 0 {name=l442 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2960 3530 1 0 {name=l443 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 2900 3940 0 0 {name=X36}
C {devices/lab_pin.sym} 3120 3530 1 0 {name=l444 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 4080 4430 1 1 {name=l445 sig_type=std_logic lab=OUT19}
C {devices/lab_pin.sym} 3920 4430 1 1 {name=l446 sig_type=std_logic lab=OUT18}
C {devices/lab_pin.sym} 3760 4430 1 1 {name=l447 sig_type=std_logic lab=OUT17}
C {devices/lab_pin.sym} 3600 4430 1 1 {name=l448 sig_type=std_logic lab=OUT16}
C {devices/lab_pin.sym} 3520 3530 1 0 {name=l449 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3600 3530 1 0 {name=l450 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 3680 3530 1 0 {name=l451 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 4160 3530 1 0 {name=l452 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4000 3530 1 0 {name=l453 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 3920 3530 1 0 {name=l454 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 3860 3940 0 0 {name=X37}
C {devices/lab_pin.sym} 4080 3530 1 0 {name=l455 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 5040 4430 1 1 {name=l456 sig_type=std_logic lab=OUT23}
C {devices/lab_pin.sym} 4880 4430 1 1 {name=l457 sig_type=std_logic lab=OUT22}
C {devices/lab_pin.sym} 4720 4430 1 1 {name=l458 sig_type=std_logic lab=OUT21}
C {devices/lab_pin.sym} 4560 4430 1 1 {name=l459 sig_type=std_logic lab=OUT20}
C {devices/lab_pin.sym} 4480 3530 1 0 {name=l460 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4560 3530 1 0 {name=l461 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 4640 3530 1 0 {name=l462 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 5120 3530 1 0 {name=l463 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4960 3530 1 0 {name=l464 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 4880 3530 1 0 {name=l465 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 4820 3940 0 0 {name=X38}
C {devices/lab_pin.sym} 5040 3530 1 0 {name=l466 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6000 4430 1 1 {name=l467 sig_type=std_logic lab=OUT27}
C {devices/lab_pin.sym} 5840 4430 1 1 {name=l468 sig_type=std_logic lab=OUT26}
C {devices/lab_pin.sym} 5680 4430 1 1 {name=l469 sig_type=std_logic lab=OUT25}
C {devices/lab_pin.sym} 5520 4430 1 1 {name=l470 sig_type=std_logic lab=OUT24}
C {devices/lab_pin.sym} 5440 3530 1 0 {name=l471 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 5520 3530 1 0 {name=l472 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 5600 3530 1 0 {name=l473 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 6080 3530 1 0 {name=l474 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 5920 3530 1 0 {name=l475 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 5840 3530 1 0 {name=l476 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 5780 3940 0 0 {name=X39}
C {devices/lab_pin.sym} 6000 3530 1 0 {name=l477 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6960 4430 1 1 {name=l478 sig_type=std_logic lab=OUT31}
C {devices/lab_pin.sym} 6800 4430 1 1 {name=l479 sig_type=std_logic lab=OUT30}
C {devices/lab_pin.sym} 6640 4430 1 1 {name=l480 sig_type=std_logic lab=OUT29}
C {devices/lab_pin.sym} 6480 4430 1 1 {name=l481 sig_type=std_logic lab=OUT28}
C {devices/lab_pin.sym} 6400 3530 1 0 {name=l482 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 6480 3530 1 0 {name=l483 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 6560 3530 1 0 {name=l484 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 7040 3530 1 0 {name=l485 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 6880 3530 1 0 {name=l486 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 6800 3530 1 0 {name=l487 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 6740 3940 0 0 {name=X40}
C {devices/lab_pin.sym} 6960 3530 1 0 {name=l488 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 240 5530 1 1 {name=l489 sig_type=std_logic lab=OUT3}
C {devices/lab_pin.sym} 80 5530 1 1 {name=l490 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} -80 5530 1 1 {name=l491 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} -240 5530 1 1 {name=l492 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} -320 4630 1 0 {name=l493 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -240 4630 1 0 {name=l494 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} -160 4630 1 0 {name=l495 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 320 4630 1 0 {name=l496 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 160 4630 1 0 {name=l497 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 80 4630 1 0 {name=l498 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 20 5040 0 0 {name=X41}
C {devices/lab_pin.sym} 240 4630 1 0 {name=l499 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} -460 5300 0 0 {name=l500 sig_type=std_logic lab=SEL23}
C {devices/lab_pin.sym} -460 5140 0 0 {name=l501 sig_type=std_logic lab=SEL22}
C {devices/lab_pin.sym} -460 4980 0 0 {name=l502 sig_type=std_logic lab=SEL21}
C {devices/lab_pin.sym} -460 4820 0 0 {name=l503 sig_type=std_logic lab=SEL20}
C {devices/lab_pin.sym} 1200 5530 1 1 {name=l504 sig_type=std_logic lab=OUT7}
C {devices/lab_pin.sym} 1040 5530 1 1 {name=l505 sig_type=std_logic lab=OUT6}
C {devices/lab_pin.sym} 880 5530 1 1 {name=l506 sig_type=std_logic lab=OUT5}
C {devices/lab_pin.sym} 720 5530 1 1 {name=l507 sig_type=std_logic lab=OUT4}
C {devices/lab_pin.sym} 640 4630 1 0 {name=l508 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 720 4630 1 0 {name=l509 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 800 4630 1 0 {name=l510 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 1280 4630 1 0 {name=l511 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 1120 4630 1 0 {name=l512 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 1040 4630 1 0 {name=l513 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 980 5040 0 0 {name=X42}
C {devices/lab_pin.sym} 1200 4630 1 0 {name=l514 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 2160 5530 1 1 {name=l515 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 2000 5530 1 1 {name=l516 sig_type=std_logic lab=OUT10}
C {devices/lab_pin.sym} 1840 5530 1 1 {name=l517 sig_type=std_logic lab=OUT9}
C {devices/lab_pin.sym} 1680 5530 1 1 {name=l518 sig_type=std_logic lab=OUT8}
C {devices/lab_pin.sym} 1600 4630 1 0 {name=l519 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1680 4630 1 0 {name=l520 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 1760 4630 1 0 {name=l521 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 2240 4630 1 0 {name=l522 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 2080 4630 1 0 {name=l523 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2000 4630 1 0 {name=l524 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 1940 5040 0 0 {name=X43}
C {devices/lab_pin.sym} 2160 4630 1 0 {name=l525 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 3120 5530 1 1 {name=l526 sig_type=std_logic lab=OUT15}
C {devices/lab_pin.sym} 2960 5530 1 1 {name=l527 sig_type=std_logic lab=OUT14}
C {devices/lab_pin.sym} 2800 5530 1 1 {name=l528 sig_type=std_logic lab=OUT13}
C {devices/lab_pin.sym} 2640 5530 1 1 {name=l529 sig_type=std_logic lab=OUT12}
C {devices/lab_pin.sym} 2560 4630 1 0 {name=l530 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2640 4630 1 0 {name=l531 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 2720 4630 1 0 {name=l532 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 3200 4630 1 0 {name=l533 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 3040 4630 1 0 {name=l534 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2960 4630 1 0 {name=l535 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 2900 5040 0 0 {name=X44}
C {devices/lab_pin.sym} 3120 4630 1 0 {name=l536 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 4080 5530 1 1 {name=l537 sig_type=std_logic lab=OUT19}
C {devices/lab_pin.sym} 3920 5530 1 1 {name=l538 sig_type=std_logic lab=OUT18}
C {devices/lab_pin.sym} 3760 5530 1 1 {name=l539 sig_type=std_logic lab=OUT17}
C {devices/lab_pin.sym} 3600 5530 1 1 {name=l540 sig_type=std_logic lab=OUT16}
C {devices/lab_pin.sym} 3520 4630 1 0 {name=l541 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3600 4630 1 0 {name=l542 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 3680 4630 1 0 {name=l543 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 4160 4630 1 0 {name=l544 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4000 4630 1 0 {name=l545 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 3920 4630 1 0 {name=l546 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 3860 5040 0 0 {name=X45}
C {devices/lab_pin.sym} 4080 4630 1 0 {name=l547 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 5040 5530 1 1 {name=l548 sig_type=std_logic lab=OUT23}
C {devices/lab_pin.sym} 4880 5530 1 1 {name=l549 sig_type=std_logic lab=OUT22}
C {devices/lab_pin.sym} 4720 5530 1 1 {name=l550 sig_type=std_logic lab=OUT21}
C {devices/lab_pin.sym} 4560 5530 1 1 {name=l551 sig_type=std_logic lab=OUT20}
C {devices/lab_pin.sym} 4480 4630 1 0 {name=l552 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4560 4630 1 0 {name=l553 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 4640 4630 1 0 {name=l554 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 5120 4630 1 0 {name=l555 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4960 4630 1 0 {name=l556 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 4880 4630 1 0 {name=l557 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 4820 5040 0 0 {name=X46}
C {devices/lab_pin.sym} 5040 4630 1 0 {name=l558 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6000 5530 1 1 {name=l559 sig_type=std_logic lab=OUT27}
C {devices/lab_pin.sym} 5840 5530 1 1 {name=l560 sig_type=std_logic lab=OUT26}
C {devices/lab_pin.sym} 5680 5530 1 1 {name=l561 sig_type=std_logic lab=OUT25}
C {devices/lab_pin.sym} 5520 5530 1 1 {name=l562 sig_type=std_logic lab=OUT24}
C {devices/lab_pin.sym} 5440 4630 1 0 {name=l563 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 5520 4630 1 0 {name=l564 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 5600 4630 1 0 {name=l565 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 6080 4630 1 0 {name=l566 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 5920 4630 1 0 {name=l567 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 5840 4630 1 0 {name=l568 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 5780 5040 0 0 {name=X47}
C {devices/lab_pin.sym} 6000 4630 1 0 {name=l569 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6960 5530 1 1 {name=l570 sig_type=std_logic lab=OUT31}
C {devices/lab_pin.sym} 6800 5530 1 1 {name=l571 sig_type=std_logic lab=OUT30}
C {devices/lab_pin.sym} 6640 5530 1 1 {name=l572 sig_type=std_logic lab=OUT29}
C {devices/lab_pin.sym} 6480 5530 1 1 {name=l573 sig_type=std_logic lab=OUT28}
C {devices/lab_pin.sym} 6400 4630 1 0 {name=l574 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 6480 4630 1 0 {name=l575 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 6560 4630 1 0 {name=l576 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 7040 4630 1 0 {name=l577 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 6880 4630 1 0 {name=l578 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 6800 4630 1 0 {name=l579 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 6740 5040 0 0 {name=X48}
C {devices/lab_pin.sym} 6960 4630 1 0 {name=l580 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 240 6610 1 1 {name=l581 sig_type=std_logic lab=OUT3}
C {devices/lab_pin.sym} 80 6610 1 1 {name=l582 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} -80 6610 1 1 {name=l583 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} -240 6610 1 1 {name=l584 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} -320 5710 1 0 {name=l585 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -240 5710 1 0 {name=l586 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} -160 5710 1 0 {name=l587 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 320 5710 1 0 {name=l588 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 160 5710 1 0 {name=l589 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 80 5710 1 0 {name=l590 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 20 6120 0 0 {name=X49}
C {devices/lab_pin.sym} 240 5710 1 0 {name=l591 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} -460 6380 0 0 {name=l592 sig_type=std_logic lab=SEL27}
C {devices/lab_pin.sym} -460 6220 0 0 {name=l593 sig_type=std_logic lab=SEL26}
C {devices/lab_pin.sym} -460 6060 0 0 {name=l594 sig_type=std_logic lab=SEL25}
C {devices/lab_pin.sym} -460 5900 0 0 {name=l595 sig_type=std_logic lab=SEL24}
C {devices/lab_pin.sym} 1200 6610 1 1 {name=l596 sig_type=std_logic lab=OUT7}
C {devices/lab_pin.sym} 1040 6610 1 1 {name=l597 sig_type=std_logic lab=OUT6}
C {devices/lab_pin.sym} 880 6610 1 1 {name=l598 sig_type=std_logic lab=OUT5}
C {devices/lab_pin.sym} 720 6610 1 1 {name=l599 sig_type=std_logic lab=OUT4}
C {devices/lab_pin.sym} 640 5710 1 0 {name=l600 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 720 5710 1 0 {name=l601 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 800 5710 1 0 {name=l602 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 1280 5710 1 0 {name=l603 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 1120 5710 1 0 {name=l604 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 1040 5710 1 0 {name=l605 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 980 6120 0 0 {name=X50}
C {devices/lab_pin.sym} 1200 5710 1 0 {name=l606 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 2160 6610 1 1 {name=l607 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 2000 6610 1 1 {name=l608 sig_type=std_logic lab=OUT10}
C {devices/lab_pin.sym} 1840 6610 1 1 {name=l609 sig_type=std_logic lab=OUT9}
C {devices/lab_pin.sym} 1680 6610 1 1 {name=l610 sig_type=std_logic lab=OUT8}
C {devices/lab_pin.sym} 1600 5710 1 0 {name=l611 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1680 5710 1 0 {name=l612 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 1760 5710 1 0 {name=l613 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 2240 5710 1 0 {name=l614 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 2080 5710 1 0 {name=l615 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2000 5710 1 0 {name=l616 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 1940 6120 0 0 {name=X51}
C {devices/lab_pin.sym} 2160 5710 1 0 {name=l617 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 3120 6610 1 1 {name=l618 sig_type=std_logic lab=OUT15}
C {devices/lab_pin.sym} 2960 6610 1 1 {name=l619 sig_type=std_logic lab=OUT14}
C {devices/lab_pin.sym} 2800 6610 1 1 {name=l620 sig_type=std_logic lab=OUT13}
C {devices/lab_pin.sym} 2640 6610 1 1 {name=l621 sig_type=std_logic lab=OUT12}
C {devices/lab_pin.sym} 2560 5710 1 0 {name=l622 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2640 5710 1 0 {name=l623 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 2720 5710 1 0 {name=l624 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 3200 5710 1 0 {name=l625 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 3040 5710 1 0 {name=l626 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2960 5710 1 0 {name=l627 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 2900 6120 0 0 {name=X52}
C {devices/lab_pin.sym} 3120 5710 1 0 {name=l628 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 4080 6610 1 1 {name=l629 sig_type=std_logic lab=OUT19}
C {devices/lab_pin.sym} 3920 6610 1 1 {name=l630 sig_type=std_logic lab=OUT18}
C {devices/lab_pin.sym} 3760 6610 1 1 {name=l631 sig_type=std_logic lab=OUT17}
C {devices/lab_pin.sym} 3600 6610 1 1 {name=l632 sig_type=std_logic lab=OUT16}
C {devices/lab_pin.sym} 3520 5710 1 0 {name=l633 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3600 5710 1 0 {name=l634 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 3680 5710 1 0 {name=l635 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 4160 5710 1 0 {name=l636 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4000 5710 1 0 {name=l637 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 3920 5710 1 0 {name=l638 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 3860 6120 0 0 {name=X53}
C {devices/lab_pin.sym} 4080 5710 1 0 {name=l639 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 5040 6610 1 1 {name=l640 sig_type=std_logic lab=OUT23}
C {devices/lab_pin.sym} 4880 6610 1 1 {name=l641 sig_type=std_logic lab=OUT22}
C {devices/lab_pin.sym} 4720 6610 1 1 {name=l642 sig_type=std_logic lab=OUT21}
C {devices/lab_pin.sym} 4560 6610 1 1 {name=l643 sig_type=std_logic lab=OUT20}
C {devices/lab_pin.sym} 4480 5710 1 0 {name=l644 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4560 5710 1 0 {name=l645 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 4640 5710 1 0 {name=l646 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 5120 5710 1 0 {name=l647 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4960 5710 1 0 {name=l648 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 4880 5710 1 0 {name=l649 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 4820 6120 0 0 {name=X54}
C {devices/lab_pin.sym} 5040 5710 1 0 {name=l650 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6000 6610 1 1 {name=l651 sig_type=std_logic lab=OUT27}
C {devices/lab_pin.sym} 5840 6610 1 1 {name=l652 sig_type=std_logic lab=OUT26}
C {devices/lab_pin.sym} 5680 6610 1 1 {name=l653 sig_type=std_logic lab=OUT25}
C {devices/lab_pin.sym} 5520 6610 1 1 {name=l654 sig_type=std_logic lab=OUT24}
C {devices/lab_pin.sym} 5440 5710 1 0 {name=l655 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 5520 5710 1 0 {name=l656 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 5600 5710 1 0 {name=l657 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 6080 5710 1 0 {name=l658 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 5920 5710 1 0 {name=l659 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 5840 5710 1 0 {name=l660 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 5780 6120 0 0 {name=X55}
C {devices/lab_pin.sym} 6000 5710 1 0 {name=l661 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6960 6610 1 1 {name=l662 sig_type=std_logic lab=OUT31}
C {devices/lab_pin.sym} 6800 6610 1 1 {name=l663 sig_type=std_logic lab=OUT30}
C {devices/lab_pin.sym} 6640 6610 1 1 {name=l664 sig_type=std_logic lab=OUT29}
C {devices/lab_pin.sym} 6480 6610 1 1 {name=l665 sig_type=std_logic lab=OUT28}
C {devices/lab_pin.sym} 6400 5710 1 0 {name=l666 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 6480 5710 1 0 {name=l667 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 6560 5710 1 0 {name=l668 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 7040 5710 1 0 {name=l669 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 6880 5710 1 0 {name=l670 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 6800 5710 1 0 {name=l671 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 6740 6120 0 0 {name=X56}
C {devices/lab_pin.sym} 6960 5710 1 0 {name=l672 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 240 7710 1 1 {name=l673 sig_type=std_logic lab=OUT3}
C {devices/lab_pin.sym} 80 7710 1 1 {name=l674 sig_type=std_logic lab=OUT2}
C {devices/lab_pin.sym} -80 7710 1 1 {name=l675 sig_type=std_logic lab=OUT1}
C {devices/lab_pin.sym} -240 7710 1 1 {name=l676 sig_type=std_logic lab=OUT0}
C {devices/lab_pin.sym} -320 6810 1 0 {name=l677 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} -240 6810 1 0 {name=l678 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} -160 6810 1 0 {name=l679 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 320 6810 1 0 {name=l680 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 160 6810 1 0 {name=l681 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 80 6810 1 0 {name=l682 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 20 7220 0 0 {name=X57}
C {devices/lab_pin.sym} 240 6810 1 0 {name=l683 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} -460 7480 0 0 {name=l684 sig_type=std_logic lab=SEL31}
C {devices/lab_pin.sym} -460 7320 0 0 {name=l685 sig_type=std_logic lab=SEL30}
C {devices/lab_pin.sym} -460 7160 0 0 {name=l686 sig_type=std_logic lab=SEL29}
C {devices/lab_pin.sym} -460 7000 0 0 {name=l687 sig_type=std_logic lab=SEL28}
C {devices/lab_pin.sym} 1200 7710 1 1 {name=l688 sig_type=std_logic lab=OUT7}
C {devices/lab_pin.sym} 1040 7710 1 1 {name=l689 sig_type=std_logic lab=OUT6}
C {devices/lab_pin.sym} 880 7710 1 1 {name=l690 sig_type=std_logic lab=OUT5}
C {devices/lab_pin.sym} 720 7710 1 1 {name=l691 sig_type=std_logic lab=OUT4}
C {devices/lab_pin.sym} 640 6810 1 0 {name=l692 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 720 6810 1 0 {name=l693 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 800 6810 1 0 {name=l694 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 1280 6810 1 0 {name=l695 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 1120 6810 1 0 {name=l696 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 1040 6810 1 0 {name=l697 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 980 7220 0 0 {name=X58}
C {devices/lab_pin.sym} 1200 6810 1 0 {name=l698 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 2160 7710 1 1 {name=l699 sig_type=std_logic lab=OUT11}
C {devices/lab_pin.sym} 2000 7710 1 1 {name=l700 sig_type=std_logic lab=OUT10}
C {devices/lab_pin.sym} 1840 7710 1 1 {name=l701 sig_type=std_logic lab=OUT9}
C {devices/lab_pin.sym} 1680 7710 1 1 {name=l702 sig_type=std_logic lab=OUT8}
C {devices/lab_pin.sym} 1600 6810 1 0 {name=l703 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 1680 6810 1 0 {name=l704 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 1760 6810 1 0 {name=l705 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 2240 6810 1 0 {name=l706 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 2080 6810 1 0 {name=l707 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2000 6810 1 0 {name=l708 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 1940 7220 0 0 {name=X59}
C {devices/lab_pin.sym} 2160 6810 1 0 {name=l709 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 3120 7710 1 1 {name=l710 sig_type=std_logic lab=OUT15}
C {devices/lab_pin.sym} 2960 7710 1 1 {name=l711 sig_type=std_logic lab=OUT14}
C {devices/lab_pin.sym} 2800 7710 1 1 {name=l712 sig_type=std_logic lab=OUT13}
C {devices/lab_pin.sym} 2640 7710 1 1 {name=l713 sig_type=std_logic lab=OUT12}
C {devices/lab_pin.sym} 2560 6810 1 0 {name=l714 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 2640 6810 1 0 {name=l715 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 2720 6810 1 0 {name=l716 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 3200 6810 1 0 {name=l717 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 3040 6810 1 0 {name=l718 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 2960 6810 1 0 {name=l719 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 2900 7220 0 0 {name=X60}
C {devices/lab_pin.sym} 3120 6810 1 0 {name=l720 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 4080 7710 1 1 {name=l721 sig_type=std_logic lab=OUT19}
C {devices/lab_pin.sym} 3920 7710 1 1 {name=l722 sig_type=std_logic lab=OUT18}
C {devices/lab_pin.sym} 3760 7710 1 1 {name=l723 sig_type=std_logic lab=OUT17}
C {devices/lab_pin.sym} 3600 7710 1 1 {name=l724 sig_type=std_logic lab=OUT16}
C {devices/lab_pin.sym} 3520 6810 1 0 {name=l725 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 3600 6810 1 0 {name=l726 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 3680 6810 1 0 {name=l727 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 4160 6810 1 0 {name=l728 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4000 6810 1 0 {name=l729 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 3920 6810 1 0 {name=l730 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 3860 7220 0 0 {name=X61}
C {devices/lab_pin.sym} 4080 6810 1 0 {name=l731 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 5040 7710 1 1 {name=l732 sig_type=std_logic lab=OUT23}
C {devices/lab_pin.sym} 4880 7710 1 1 {name=l733 sig_type=std_logic lab=OUT22}
C {devices/lab_pin.sym} 4720 7710 1 1 {name=l734 sig_type=std_logic lab=OUT21}
C {devices/lab_pin.sym} 4560 7710 1 1 {name=l735 sig_type=std_logic lab=OUT20}
C {devices/lab_pin.sym} 4480 6810 1 0 {name=l736 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 4560 6810 1 0 {name=l737 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 4640 6810 1 0 {name=l738 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 5120 6810 1 0 {name=l739 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 4960 6810 1 0 {name=l740 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 4880 6810 1 0 {name=l741 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 4820 7220 0 0 {name=X62}
C {devices/lab_pin.sym} 5040 6810 1 0 {name=l742 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6000 7710 1 1 {name=l743 sig_type=std_logic lab=OUT27}
C {devices/lab_pin.sym} 5840 7710 1 1 {name=l744 sig_type=std_logic lab=OUT26}
C {devices/lab_pin.sym} 5680 7710 1 1 {name=l745 sig_type=std_logic lab=OUT25}
C {devices/lab_pin.sym} 5520 7710 1 1 {name=l746 sig_type=std_logic lab=OUT24}
C {devices/lab_pin.sym} 5440 6810 1 0 {name=l747 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 5520 6810 1 0 {name=l748 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 5600 6810 1 0 {name=l749 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 6080 6810 1 0 {name=l750 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 5920 6810 1 0 {name=l751 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 5840 6810 1 0 {name=l752 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 5780 7220 0 0 {name=X63}
C {devices/lab_pin.sym} 6000 6810 1 0 {name=l753 sig_type=std_logic lab=SouthEast}
C {devices/lab_pin.sym} 6960 7710 1 1 {name=l754 sig_type=std_logic lab=OUT31}
C {devices/lab_pin.sym} 6800 7710 1 1 {name=l755 sig_type=std_logic lab=OUT30}
C {devices/lab_pin.sym} 6640 7710 1 1 {name=l756 sig_type=std_logic lab=OUT29}
C {devices/lab_pin.sym} 6480 7710 1 1 {name=l757 sig_type=std_logic lab=OUT28}
C {devices/lab_pin.sym} 6400 6810 1 0 {name=l758 sig_type=std_logic lab=avdd}
C {devices/lab_pin.sym} 6480 6810 1 0 {name=l759 sig_type=std_logic lab=Vgh}
C {devices/lab_pin.sym} 6560 6810 1 0 {name=l760 sig_type=std_logic lab=Vgv}
C {devices/lab_pin.sym} 7040 6810 1 0 {name=l761 sig_type=std_logic lab=agnd}
C {devices/lab_pin.sym} 6880 6810 1 0 {name=l762 sig_type=std_logic lab=West}
C {devices/lab_pin.sym} 6800 6810 1 0 {name=l763 sig_type=std_logic lab=North}
C {HW4_RAM_readout/pixel_4x4.sym} 6740 7220 0 0 {name=X64}
C {devices/lab_pin.sym} 6960 6810 1 0 {name=l764 sig_type=std_logic lab=SouthEast}
C {devices/iopin.sym} -790 -520 0 1 {name=p3 lab=OUT4}
C {devices/iopin.sym} -790 -540 0 1 {name=p4 lab=OUT5}
C {devices/iopin.sym} -790 -560 0 1 {name=p5 lab=OUT6}
C {devices/iopin.sym} -790 -580 0 1 {name=p11 lab=OUT7}
C {devices/iopin.sym} -790 -600 0 1 {name=p13 lab=OUT8}
C {devices/iopin.sym} -790 -620 0 1 {name=p14 lab=OUT9}
C {devices/iopin.sym} -790 -640 0 1 {name=p15 lab=OUT10}
C {devices/iopin.sym} -790 -660 0 1 {name=p16 lab=OUT11}
C {devices/iopin.sym} -790 -680 0 1 {name=p17 lab=OUT12}
C {devices/iopin.sym} -790 -720 0 1 {name=p19 lab=OUT14}
C {devices/iopin.sym} -790 -740 0 1 {name=p20 lab=OUT15}
C {devices/iopin.sym} -790 -700 0 1 {name=p21 lab=OUT13}
C {devices/iopin.sym} -790 -760 0 1 {name=p22 lab=OUT16}
C {devices/iopin.sym} -790 -780 0 1 {name=p23 lab=OUT17}
C {devices/iopin.sym} -790 -800 0 1 {name=p25 lab=OUT18}
C {devices/iopin.sym} -790 -820 0 1 {name=p26 lab=OUT19}
C {devices/iopin.sym} -790 -840 0 1 {name=p27 lab=OUT20}
C {devices/iopin.sym} -790 -860 0 1 {name=p28 lab=OUT21}
C {devices/iopin.sym} -790 -880 0 1 {name=p29 lab=OUT22}
C {devices/iopin.sym} -790 -900 0 1 {name=p30 lab=OUT23}
C {devices/iopin.sym} -790 -920 0 1 {name=p31 lab=OUT24}
C {devices/iopin.sym} -790 -940 0 1 {name=p32 lab=OUT25}
C {devices/iopin.sym} -790 -960 0 1 {name=p33 lab=OUT26}
C {devices/iopin.sym} -790 -980 0 1 {name=p34 lab=OUT27}
C {devices/iopin.sym} -790 -1000 0 1 {name=p35 lab=OUT28}
C {devices/iopin.sym} -790 -1040 0 1 {name=p36 lab=OUT30}
C {devices/iopin.sym} -790 -1060 0 1 {name=p37 lab=OUT31}
C {devices/iopin.sym} -790 -1020 0 1 {name=p38 lab=OUT29}
C {devices/iopin.sym} -910 -520 0 1 {name=p43 lab=SEL4}
C {devices/iopin.sym} -910 -540 0 1 {name=p44 lab=SEL5}
C {devices/iopin.sym} -910 -560 0 1 {name=p45 lab=SEL6}
C {devices/iopin.sym} -910 -580 0 1 {name=p46 lab=SEL7}
C {devices/iopin.sym} -910 -600 0 1 {name=p47 lab=SEL8}
C {devices/iopin.sym} -910 -620 0 1 {name=p48 lab=SEL9}
C {devices/iopin.sym} -910 -640 0 1 {name=p49 lab=SEL10}
C {devices/iopin.sym} -910 -660 0 1 {name=p50 lab=SEL11}
C {devices/iopin.sym} -910 -680 0 1 {name=p51 lab=SEL12}
C {devices/iopin.sym} -910 -720 0 1 {name=p52 lab=SEL14}
C {devices/iopin.sym} -910 -740 0 1 {name=p55 lab=SEL15}
C {devices/iopin.sym} -910 -700 0 1 {name=p56 lab=SEL13}
C {devices/iopin.sym} -910 -760 0 1 {name=p57 lab=SEL16}
C {devices/iopin.sym} -910 -780 0 1 {name=p58 lab=SEL17}
C {devices/iopin.sym} -910 -800 0 1 {name=p59 lab=SEL18}
C {devices/iopin.sym} -910 -820 0 1 {name=p61 lab=SEL19}
C {devices/iopin.sym} -910 -840 0 1 {name=p62 lab=SEL20}
C {devices/iopin.sym} -910 -860 0 1 {name=p63 lab=SEL21}
C {devices/iopin.sym} -910 -880 0 1 {name=p64 lab=SEL22}
C {devices/iopin.sym} -910 -900 0 1 {name=p65 lab=SEL23}
C {devices/iopin.sym} -910 -920 0 1 {name=p67 lab=SEL24}
C {devices/iopin.sym} -910 -940 0 1 {name=p68 lab=SEL25}
C {devices/iopin.sym} -910 -960 0 1 {name=p69 lab=SEL26}
C {devices/iopin.sym} -910 -980 0 1 {name=p70 lab=SEL27}
C {devices/iopin.sym} -910 -1000 0 1 {name=p71 lab=SEL28}
C {devices/iopin.sym} -910 -1040 0 1 {name=p73 lab=SEL30}
C {devices/iopin.sym} -910 -1060 0 1 {name=p74 lab=SEL31}
C {devices/iopin.sym} -910 -1020 0 1 {name=p75 lab=SEL29}
