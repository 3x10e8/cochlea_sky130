v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {LO generation} 95 920 3 0 0.4 0.4 {}
T {Phi1/Phi2/Div2 generation} 515 970 3 0 0.4 0.4 {}
T {ROM} -50 1460 3 0 0.6 0.6 {}
T {Sparse Decoder} -55 2160 3 0 0.6 0.6 {}
T {Gray Counter} -55 2545 3 0 0.6 0.6 {}
N 535 510 585 510 { lab=opi}
N 535 530 585 530 { lab=omi}
N 535 570 585 570 { lab=opq}
N 535 590 585 590 { lab=omq}
N -160 530 345 530 { lab=inp}
N -80 570 345 570 { lab=inm}
N 290 750 405 750 { lab=loq}
N 405 620 405 750 { lab=loq}
N -160 1000 325 1000 { lab=fclk}
N 425 880 435 880 { lab=phi1}
N 435 620 435 880 { lab=phi1}
N 425 920 475 920 { lab=phi2}
N 475 620 475 920 { lab=phi2}
N 425 900 455 900 { lab=#net1}
N 455 620 455 900 { lab=#net1}
N 425 940 495 940 { lab=#net2}
N 495 620 495 940 { lab=#net2}
N 425 1000 585 1000 { lab=fclkdiv2}
N 15 2210 15 2330 { lab=A0}
N 35 2210 35 2330 { lab=A1}
N 55 2210 55 2330 { lab=A2}
N 75 2210 75 2330 { lab=A3}
N 95 2210 95 2330 { lab=A4}
N 115 2210 115 2330 { lab=A5}
N 135 2300 135 2330 { lab=#net3}
N 155 2300 155 2330 { lab=#net4}
N 15 1640 15 1890 { lab=s2}
N 35 1640 35 1890 { lab=s3}
N 55 1640 55 1890 { lab=s4}
N 75 1640 75 1890 { lab=s9}
N 95 1640 95 1890 { lab=s10}
N 115 1640 115 1890 { lab=s13}
N 135 1640 135 1890 { lab=s17}
N 155 1640 155 1890 { lab=s21}
N 175 1640 175 1890 { lab=s23}
N 215 1695 215 1890 { lab=s32}
N 195 1695 215 1695 { lab=s32}
N 195 1640 195 1695 { lab=s32}
N 235 1680 235 1890 { lab=s40}
N 215 1680 235 1680 { lab=s40}
N 215 1640 215 1680 { lab=s40}
N 175 1735 245 1735 { lab=s23}
N 245 1735 250 1735 { lab=s23}
N 250 1640 250 1735 { lab=s23}
N 195 1740 195 1890 { lab=s31}
N 195 1740 265 1740 { lab=s31}
N 265 1740 270 1740 { lab=s31}
N 270 1640 270 1740 { lab=s31}
N 235 1745 290 1745 { lab=s40}
N 290 1640 290 1745 { lab=s40}
N 255 1760 255 1890 { lab=s42}
N 310 1640 310 1755 { lab=s42}
N 255 1755 310 1755 { lab=s42}
N 255 1755 255 1760 { lab=s42}
N 275 1770 275 1890 { lab=s46}
N 275 1770 330 1770 { lab=s46}
N 330 1640 330 1770 { lab=s46}
N 350 1640 350 1780 { lab=s50}
N 295 1780 350 1780 { lab=s50}
N 295 1780 295 1890 { lab=s50}
N 315 1790 315 1890 { lab=s53}
N 315 1790 370 1790 { lab=s53}
N 370 1640 370 1790 { lab=s53}
N 335 1800 335 1890 { lab=s54}
N 335 1800 390 1800 { lab=s54}
N 390 1640 390 1800 { lab=s54}
N 355 1815 355 1890 { lab=s59}
N 355 1810 355 1815 { lab=s59}
N 355 1810 405 1810 { lab=s59}
N 405 1810 410 1810 { lab=s59}
N 410 1640 410 1810 { lab=s59}
N 375 1820 375 1890 { lab=s60}
N 375 1820 430 1820 { lab=s60}
N 430 1640 430 1820 { lab=s60}
N 395 1830 395 1890 { lab=s61}
N 395 1830 450 1830 { lab=s61}
N 450 1640 450 1830 { lab=s61}
N 350 1220 350 1280 { lab=#net5}
N 135 2215 135 2300 { lab=#net3}
N 135 2215 465 2215 { lab=#net3}
N 465 1270 465 2215 { lab=#net3}
N 390 1270 465 1270 { lab=#net3}
N 390 1220 390 1270 { lab=#net3}
N 155 2240 155 2300 { lab=#net4}
N 155 2240 490 2240 { lab=#net4}
N 490 1260 490 2240 { lab=#net4}
N 350 1205 350 1220 { lab=#net5}
N 390 1205 390 1220 { lab=#net3}
N 155 1205 155 1250 { lab=#net4}
N 155 1250 490 1250 { lab=#net4}
N 490 1250 490 1255 { lab=#net4}
N 490 1255 490 1260 { lab=#net4}
N 115 1205 115 1285 { lab=#net6}
N 135 660 365 660 { lab=loi}
N 365 620 365 660 { lab=loi}
N 160 750 290 750 { lab=loq}
N 135 660 135 1085 { lab=loi}
N 160 750 160 1085 { lab=loq}
N 160 1085 370 1085 { lab=loq}
N 35 2560 35 2600 { lab=EN}
N -60 2600 35 2600 { lab=EN}
N 130 2560 130 2640 { lab=RSTb}
N -60 2640 130 2640 { lab=RSTb}
N -60 2680 260 2680 { lab=mclk}
N 260 2440 260 2680 { lab=mclk}
N 215 2440 260 2440 { lab=mclk}
N -160 680 -110 680 { lab=EN}
N -160 800 -110 800 { lab=RSTb}
N -160 900 -110 900 { lab=Vmid}
N 300 960 300 980 { lab=Vmid}
N 300 980 325 980 { lab=Vmid}
N 280 960 325 960 { lab=Vmid}
N 280 880 325 880 { lab=RSTb}
N 425 960 445 960 { lab=#net7}
N 425 980 445 980 { lab=#net8}
N -160 1100 -120 1100 { lab=mclk}
C {devices/netlist.sym} -15 165 0 0 {name=SPICE only_toplevel=false value="
.lib /home/sky/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.include /home/sky/sky130A/libs.ref/sky130_fd_sc_lp/spice/sky130_fd_sc_lp.spice
.options abstol=1e-14 reltol=1e-4
.param ftest = 10k
.param Atest = 0.3
.param mclk=\{256*ftest\}
.param m_dc = 0.5
* ratio of phi / lo clk:
.param ratio_fm = 1
.param f_dc = 0.5
.param fclk = \{mclk*ratio_fm\}
.param tau=\{(16^2)*1/fclk\}
.param tend=\{4*tau\}
*start all caps with 0 charge:
*.ic included in cap symbols
.tran \{1/fclk/100\} \{tend\}
.save all
"}
C {devices/vsource.sym} -160 560 0 0 {name=Vinp value="DC 0 SIN(0.6 \{Atest\} \{ftest\})"
*SIN (0.6 0.6 1k)"}
C {devices/gnd.sym} -160 590 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 585 510 2 0 {name=l1 sig_type=std_logic lab=opi}
C {devices/lab_pin.sym} -160 530 0 0 {name=l5 sig_type=std_logic lab=inp}
C {devices/vsource.sym} -160 410 0 0 {name=VDD value="DC 1.2"}
C {devices/vdd.sym} -160 380 0 0 {name=l7 lab=VDD}
C {devices/lab_pin.sym} 585 530 2 0 {name=l2 sig_type=std_logic lab=omi}
C {devices/lab_pin.sym} 585 570 2 0 {name=l9 sig_type=std_logic lab=opq}
C {devices/lab_pin.sym} 585 590 2 0 {name=l14 sig_type=std_logic lab=omq}
C {devices/vsource.sym} -80 600 0 0 {name=Vinm value="DC 0 SIN(0.6 \{-Atest\} \{ftest\})"
*SIN (0.6 0.6 1k)"}
C {devices/gnd.sym} -80 630 0 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} -80 570 0 0 {name=l11 sig_type=std_logic lab=inm}
C {devices/vsource.sym} -160 1030 0 0 {name=Vphi value="DC 0 PULSE (0 1.2 1n 1n 1n \{f_dc*1/fclk\} \{1/fclk\} 0"
*SIN (0.6 0.6 1k)"}
C {devices/gnd.sym} -160 1060 0 0 {name=l31 lab=GND}
C {devices/gnd.sym} -160 440 0 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} 365 650 0 0 {name=l13 sig_type=std_logic lab=loi}
C {devices/lab_pin.sym} 405 740 0 0 {name=l15 sig_type=std_logic lab=loq}
C {devices/lab_pin.sym} 425 880 1 0 {name=l17 sig_type=std_logic lab=phi1}
C {wavelet_channel/wavelet_iq.sym} 465 550 0 0 {name=X1 W=20 L=20}
C {clkgen/filter_clkgen.sym} 375 940 0 0 {name=X2}
C {devices/lab_pin.sym} 465 920 1 0 {name=l6 sig_type=std_logic lab=phi2}
C {devices/lab_pin.sym} 15 1890 1 0 {name=l21 sig_type=std_logic lab=s2}
C {devices/lab_pin.sym} 35 1890 1 0 {name=l22 sig_type=std_logic lab=s3}
C {devices/lab_pin.sym} 55 1890 1 0 {name=l23 sig_type=std_logic lab=s4}
C {devices/lab_pin.sym} 75 1890 1 0 {name=l24 sig_type=std_logic lab=s9}
C {devices/lab_pin.sym} 95 1890 1 0 {name=l25 sig_type=std_logic lab=s10}
C {devices/lab_pin.sym} 115 1890 1 0 {name=l26 sig_type=std_logic lab=s13}
C {devices/lab_pin.sym} 135 1890 1 0 {name=l27 sig_type=std_logic lab=s17}
C {devices/lab_pin.sym} 155 1890 1 0 {name=l28 sig_type=std_logic lab=s21}
C {devices/lab_pin.sym} 175 1890 1 0 {name=l29 sig_type=std_logic lab=s23}
C {devices/lab_pin.sym} 195 1890 1 0 {name=l30 sig_type=std_logic lab=s31}
C {devices/lab_pin.sym} 215 1890 1 0 {name=l10 sig_type=std_logic lab=s32}
C {devices/lab_pin.sym} 235 1890 1 0 {name=l32 sig_type=std_logic lab=s40}
C {devices/lab_pin.sym} 255 1890 1 0 {name=l33 sig_type=std_logic lab=s42}
C {devices/lab_pin.sym} 275 1890 1 0 {name=l34 sig_type=std_logic lab=s46}
C {devices/lab_pin.sym} 295 1890 1 0 {name=l35 sig_type=std_logic lab=s50}
C {devices/lab_pin.sym} 315 1890 1 0 {name=l36 sig_type=std_logic lab=s53}
C {devices/lab_pin.sym} 335 1890 1 0 {name=l37 sig_type=std_logic lab=s54}
C {devices/lab_pin.sym} 355 1890 1 0 {name=l12 sig_type=std_logic lab=s59}
C {devices/lab_pin.sym} 375 1890 1 0 {name=l39 sig_type=std_logic lab=s60}
C {devices/lab_pin.sym} 395 1890 1 0 {name=l40 sig_type=std_logic lab=s61}
C {devices/lab_pin.sym} 115 2210 3 0 {name=l18 sig_type=std_logic lab=A5}
C {devices/lab_pin.sym} 95 2210 3 0 {name=l19 sig_type=std_logic lab=A4}
C {devices/lab_pin.sym} 75 2210 3 0 {name=l20 sig_type=std_logic lab=A3}
C {devices/lab_pin.sym} 55 2210 3 0 {name=l41 sig_type=std_logic lab=A2}
C {devices/lab_pin.sym} 35 2210 3 0 {name=l42 sig_type=std_logic lab=A1}
C {devices/lab_pin.sym} 15 2210 3 0 {name=l43 sig_type=std_logic lab=A0}
C {devices/vsource.sym} -160 710 0 0 {name=Ven value=1.2}
C {devices/gnd.sym} -160 740 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} -60 2600 0 0 {name=l86 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} -60 2640 0 0 {name=l87 sig_type=std_logic lab=RSTb}
C {devices/vsource.sym} -160 830 0 0 {name=Vrstb value="DC 0 PWL(0 0 2u 0 2.01u 1.2 10u 1.2)"}
C {devices/gnd.sym} -160 860 0 0 {name=l88 lab=GND}
C {devices/lab_pin.sym} -60 2680 0 0 {name=l90 sig_type=std_logic lab=mclk}
C {Asyn_rst_gray_counter/asyn_rst_gray_counter.sym} 410 -3333.75 3 0 {name=X3}
C {sparse_nor/sparse_nor.sym} -5870 740 3 0 {name=X4}
C {sparse_nor/sparse_nor.sym} -6105 740 3 0 {name=X5}
C {sky130_stdcells/xor2_1.sym} 135 1145 3 0 {name=x3 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sky130_stdcells/xor2_1.sym} 370 1145 3 0 {name=x1 VGND=GND VNB=GND VPB=VDD VPWR=VDD prefix=sky130_fd_sc_lp__ }
C {sparse_decoder/sparse_decoder_crude.sym} -2835 4780 3 0 {name=X6}
C {devices/lab_pin.sym} -110 680 2 0 {name=l8 sig_type=std_logic lab=EN}
C {devices/lab_pin.sym} -110 800 2 0 {name=l16 sig_type=std_logic lab=RSTb}
C {devices/lab_pin.sym} -160 1000 0 0 {name=l44 sig_type=std_logic lab=fclk}
C {devices/vsource.sym} -160 930 0 0 {name=Vmid value=0.6}
C {devices/gnd.sym} -160 960 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} -110 900 2 0 {name=l46 sig_type=std_logic lab=Vmid}
C {devices/lab_pin.sym} 280 960 0 0 {name=l47 sig_type=std_logic lab=Vmid}
C {devices/lab_pin.sym} 280 880 0 0 {name=l48 sig_type=std_logic lab=RSTb}
C {devices/lab_pin.sym} 585 1000 2 0 {name=l49 sig_type=std_logic lab=fclkdiv2}
C {devices/vsource.sym} -160 1130 0 0 {name=Vmclk value="DC 0 PULSE (0 1.2 \{1/2/mclk\} 1n 1n \{m_dc*1/mclk\} \{1/mclk\} 0"
*SIN (0.6 0.6 1k)"}
C {devices/gnd.sym} -160 1160 0 0 {name=l50 lab=GND}
C {devices/lab_pin.sym} -160 1100 0 0 {name=l51 sig_type=std_logic lab=mclk}
