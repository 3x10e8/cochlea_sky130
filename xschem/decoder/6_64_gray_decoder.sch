v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 240 -90 240 -60 {}
N 220 10180 220 10210 {}
N 360 10290 360 10320 {}
N 480 10290 480 10320 {}
N 600 10290 600 10320 {}
N 720 10290 720 10320 {}
N 840 10290 840 10320 {}
N 960 10290 960 10320 {}
N 1090 10100 1110 10100 {}
N 1090 9940 1110 9940 {}
N 1090 9780 1110 9780 {}
N 1090 9620 1110 9620 {}
N 1090 9460 1110 9460 {}
N 1090 9300 1110 9300 {}
N 1090 9140 1110 9140 {}
N 1090 8980 1110 8980 {}
N 1090 8820 1110 8820 {}
N 1090 8660 1110 8660 {}
N 1090 8500 1110 8500 {}
N 1090 8340 1110 8340 {}
N 1090 8180 1110 8180 {}
N 1090 8020 1110 8020 {}
N 1090 7860 1110 7860 {}
N 1090 7700 1110 7700 {}
N 1090 7540 1110 7540 {}
N 1090 7380 1110 7380 {}
N 1090 7220 1110 7220 {}
N 1090 7060 1110 7060 {}
N 1090 6900 1110 6900 {}
N 1090 6740 1110 6740 {}
N 1090 6580 1110 6580 {}
N 1090 6420 1110 6420 {}
N 1090 6260 1110 6260 {}
N 1090 6100 1110 6100 {}
N 1090 5940 1110 5940 {}
N 1090 5780 1110 5780 {}
N 1090 5620 1110 5620 {}
N 1090 5460 1110 5460 {}
N 1090 5300 1110 5300 {}
N 1090 5140 1110 5140 {}
N 1090 4980 1110 4980 {}
N 1090 4820 1110 4820 {}
N 1090 4660 1110 4660 {}
N 1090 4500 1110 4500 {}
N 1090 4340 1110 4340 {}
N 1090 4180 1110 4180 {}
N 1090 4020 1110 4020 {}
N 1090 3860 1110 3860 {}
N 1090 3700 1110 3700 {}
N 1090 3540 1110 3540 {}
N 1090 3380 1110 3380 {}
N 1090 3220 1110 3220 {}
N 1090 3060 1110 3060 {}
N 1090 2900 1110 2900 {}
N 1090 2740 1110 2740 {}
N 1090 2580 1110 2580 {}
N 1090 2420 1110 2420 {}
N 1090 2260 1110 2260 {}
N 1090 2100 1110 2100 {}
N 1090 1940 1110 1940 {}
N 1090 1780 1110 1780 {}
N 1090 1620 1110 1620 {}
N 1090 1460 1110 1460 {}
N 1090 1300 1110 1300 {}
N 1090 1140 1110 1140 {}
N 1090 980 1110 980 {}
N 1090 820 1110 820 {}
N 1090 660 1110 660 {}
N 1090 500 1110 500 {}
N 1090 340 1110 340 {}
N 1090 180 1110 180 {}
N 1090 20 1110 20 {}
C {decoder/decoder_cell_0.sym} 700 110 0 0 {name=X5}
C {decoder/decoder_cell_0.sym} 820 110 0 0 {name=X6}
C {decoder/decoder_cell_0.sym} 700 270 0 0 {name=X1}
C {decoder/decoder_cell_0.sym} 1060 270 0 1 {name=X2}
C {decoder/decoder_cell_0.sym} 1060 430 0 1 {name=X3}
C {decoder/decoder_cell_0.sym} 940 430 0 1 {name=X4}
C {decoder/decoder_cell_0.sym} 940 590 0 1 {name=X7}
C {decoder/decoder_cell_0.sym} 820 590 0 0 {name=X8}
C {decoder/decoder_cell_0.sym} 580 110 0 0 {name=X9}
C {decoder/decoder_cell_0.sym} 460 110 0 0 {name=X10}
C {decoder/decoder_cell_0.sym} 340 110 0 0 {name=X11}
C {decoder/decoder_cell_0.sym} 220 110 0 0 {name=X12}
C {decoder/decoder_cell_0.sym} 580 270 0 0 {name=X13}
C {decoder/decoder_cell_0.sym} 460 270 0 0 {name=X14}
C {decoder/decoder_cell_0.sym} 340 270 0 0 {name=X15}
C {decoder/decoder_cell_0.sym} 220 270 0 0 {name=X16}
C {decoder/decoder_cell_0.sym} 580 430 0 0 {name=X17}
C {decoder/decoder_cell_0.sym} 460 430 0 0 {name=X18}
C {decoder/decoder_cell_0.sym} 340 430 0 0 {name=X19}
C {decoder/decoder_cell_0.sym} 220 430 0 0 {name=X20}
C {decoder/decoder_cell_0.sym} 580 590 0 0 {name=X21}
C {decoder/decoder_cell_0.sym} 460 590 0 0 {name=X22}
C {decoder/decoder_cell_0.sym} 340 590 0 0 {name=X23}
C {decoder/decoder_cell_0.sym} 220 590 0 0 {name=X24}
C {decoder/decoder_cell_0.sym} 460 750 0 0 {name=X25}
C {decoder/decoder_cell_0.sym} 340 750 0 0 {name=X26}
C {decoder/decoder_cell_0.sym} 220 750 0 0 {name=X27}
C {decoder/decoder_cell_0.sym} 460 910 0 0 {name=X28}
C {decoder/decoder_cell_0.sym} 340 910 0 0 {name=X29}
C {decoder/decoder_cell_0.sym} 220 910 0 0 {name=X30}
C {decoder/decoder_cell_0.sym} 460 1070 0 0 {name=X31}
C {decoder/decoder_cell_0.sym} 340 1070 0 0 {name=X32}
C {decoder/decoder_cell_0.sym} 220 1070 0 0 {name=X33}
C {decoder/decoder_cell_0.sym} 460 1230 0 0 {name=X34}
C {decoder/decoder_cell_0.sym} 340 1230 0 0 {name=X35}
C {decoder/decoder_cell_0.sym} 220 1230 0 0 {name=X36}
C {decoder/decoder_cell_0.sym} 820 750 0 1 {name=X37}
C {decoder/decoder_cell_0.sym} 940 750 0 1 {name=X38}
C {decoder/decoder_cell_0.sym} 820 750 0 0 {name=X39}
C {decoder/decoder_cell_0.sym} 820 910 0 1 {name=X40}
C {decoder/decoder_cell_0.sym} 940 910 0 1 {name=X41}
C {decoder/decoder_cell_0.sym} 1060 910 0 1 {name=X42}
C {decoder/decoder_cell_0.sym} 820 1070 0 1 {name=X43}
C {decoder/decoder_cell_0.sym} 700 1070 0 0 {name=X44}
C {decoder/decoder_cell_0.sym} 1060 1070 0 1 {name=X45}
C {decoder/decoder_cell_0.sym} 820 1230 0 1 {name=X46}
C {decoder/decoder_cell_0.sym} 700 1230 0 0 {name=X47}
C {decoder/decoder_cell_0.sym} 820 1230 0 0 {name=X48}
C {decoder/decoder_cell_0.sym} 340 1390 0 0 {name=X49}
C {decoder/decoder_cell_0.sym} 220 1390 0 0 {name=X50}
C {decoder/decoder_cell_0.sym} 340 1550 0 0 {name=X51}
C {decoder/decoder_cell_0.sym} 220 1550 0 0 {name=X52}
C {decoder/decoder_cell_0.sym} 340 1710 0 0 {name=X53}
C {decoder/decoder_cell_0.sym} 220 1710 0 0 {name=X54}
C {decoder/decoder_cell_0.sym} 340 1870 0 0 {name=X55}
C {decoder/decoder_cell_0.sym} 220 1870 0 0 {name=X56}
C {decoder/decoder_cell_0.sym} 340 2030 0 0 {name=X57}
C {decoder/decoder_cell_0.sym} 220 2030 0 0 {name=X58}
C {decoder/decoder_cell_0.sym} 340 2190 0 0 {name=X59}
C {decoder/decoder_cell_0.sym} 220 2190 0 0 {name=X60}
C {decoder/decoder_cell_0.sym} 340 2350 0 0 {name=X61}
C {decoder/decoder_cell_0.sym} 220 2350 0 0 {name=X62}
C {decoder/decoder_cell_0.sym} 340 2510 0 0 {name=X63}
C {decoder/decoder_cell_0.sym} 220 2510 0 0 {name=X64}
C {decoder/decoder_cell_0.sym} 700 1390 0 1 {name=X65}
C {decoder/decoder_cell_0.sym} 700 1550 0 1 {name=X66}
C {decoder/decoder_cell_0.sym} 700 1710 0 1 {name=X67}
C {decoder/decoder_cell_0.sym} 700 1870 0 1 {name=X68}
C {decoder/decoder_cell_0.sym} 700 2030 0 1 {name=X69}
C {decoder/decoder_cell_0.sym} 700 2190 0 1 {name=X70}
C {decoder/decoder_cell_0.sym} 700 2350 0 1 {name=X71}
C {decoder/decoder_cell_0.sym} 700 2510 0 1 {name=X72}
C {decoder/decoder_cell_0.sym} 820 1390 0 1 {name=X73}
C {decoder/decoder_cell_0.sym} 820 1550 0 1 {name=X74}
C {decoder/decoder_cell_0.sym} 820 1710 0 1 {name=X75}
C {decoder/decoder_cell_0.sym} 820 1870 0 1 {name=X76}
C {decoder/decoder_cell_0.sym} 700 1390 0 0 {name=X77}
C {decoder/decoder_cell_0.sym} 820 1390 0 0 {name=X78}
C {decoder/decoder_cell_0.sym} 700 1550 0 0 {name=X79}
C {decoder/decoder_cell_0.sym} 1060 1550 0 1 {name=X80}
C {decoder/decoder_cell_0.sym} 1060 1710 0 1 {name=X81}
C {decoder/decoder_cell_0.sym} 940 1710 0 1 {name=X82}
C {decoder/decoder_cell_0.sym} 940 1870 0 1 {name=X83}
C {decoder/decoder_cell_0.sym} 820 1870 0 0 {name=X84}
C {decoder/decoder_cell_0.sym} 580 2030 0 0 {name=X85}
C {decoder/decoder_cell_0.sym} 580 2190 0 0 {name=X86}
C {decoder/decoder_cell_0.sym} 580 2350 0 0 {name=X87}
C {decoder/decoder_cell_0.sym} 580 2510 0 0 {name=X88}
C {decoder/decoder_cell_0.sym} 940 2030 0 1 {name=X89}
C {decoder/decoder_cell_0.sym} 820 2030 0 0 {name=X90}
C {decoder/decoder_cell_0.sym} 940 2190 0 1 {name=X91}
C {decoder/decoder_cell_0.sym} 1060 2190 0 1 {name=X92}
C {decoder/decoder_cell_0.sym} 700 2350 0 0 {name=X93}
C {decoder/decoder_cell_0.sym} 1060 2350 0 1 {name=X94}
C {decoder/decoder_cell_0.sym} 700 2510 0 0 {name=X95}
C {decoder/decoder_cell_0.sym} 820 2510 0 0 {name=X96}
C {decoder/decoder_cell_0.sym} 700 2670 0 0 {name=X97}
C {decoder/decoder_cell_0.sym} 820 2670 0 0 {name=X98}
C {decoder/decoder_cell_0.sym} 700 2830 0 0 {name=X99}
C {decoder/decoder_cell_0.sym} 1060 2830 0 1 {name=X100}
C {decoder/decoder_cell_0.sym} 1060 2990 0 1 {name=X101}
C {decoder/decoder_cell_0.sym} 940 2990 0 1 {name=X102}
C {decoder/decoder_cell_0.sym} 940 3150 0 1 {name=X103}
C {decoder/decoder_cell_0.sym} 820 3150 0 0 {name=X104}
C {decoder/decoder_cell_0.sym} 580 2670 0 0 {name=X105}
C {decoder/decoder_cell_0.sym} 580 2830 0 0 {name=X106}
C {decoder/decoder_cell_0.sym} 580 2990 0 0 {name=X107}
C {decoder/decoder_cell_0.sym} 580 3150 0 0 {name=X108}
C {decoder/decoder_cell_0.sym} 820 3310 0 1 {name=X109}
C {decoder/decoder_cell_0.sym} 940 3310 0 1 {name=X110}
C {decoder/decoder_cell_0.sym} 820 3310 0 0 {name=X111}
C {decoder/decoder_cell_0.sym} 820 3470 0 1 {name=X112}
C {decoder/decoder_cell_0.sym} 940 3470 0 1 {name=X113}
C {decoder/decoder_cell_0.sym} 1060 3470 0 1 {name=X114}
C {decoder/decoder_cell_0.sym} 820 3630 0 1 {name=X115}
C {decoder/decoder_cell_0.sym} 700 3630 0 0 {name=X116}
C {decoder/decoder_cell_0.sym} 1060 3630 0 1 {name=X117}
C {decoder/decoder_cell_0.sym} 820 3790 0 1 {name=X118}
C {decoder/decoder_cell_0.sym} 700 3790 0 0 {name=X119}
C {decoder/decoder_cell_0.sym} 820 3790 0 0 {name=X120}
C {decoder/decoder_cell_0.sym} 340 2670 0 0 {name=X121}
C {decoder/decoder_cell_0.sym} 220 2670 0 0 {name=X122}
C {decoder/decoder_cell_0.sym} 340 2830 0 0 {name=X123}
C {decoder/decoder_cell_0.sym} 220 2830 0 0 {name=X124}
C {decoder/decoder_cell_0.sym} 340 2990 0 0 {name=X125}
C {decoder/decoder_cell_0.sym} 220 2990 0 0 {name=X126}
C {decoder/decoder_cell_0.sym} 340 3150 0 0 {name=X127}
C {decoder/decoder_cell_0.sym} 220 3150 0 0 {name=X128}
C {decoder/decoder_cell_0.sym} 340 3310 0 0 {name=X129}
C {decoder/decoder_cell_0.sym} 220 3310 0 0 {name=X130}
C {decoder/decoder_cell_0.sym} 340 3470 0 0 {name=X131}
C {decoder/decoder_cell_0.sym} 220 3470 0 0 {name=X132}
C {decoder/decoder_cell_0.sym} 340 3630 0 0 {name=X133}
C {decoder/decoder_cell_0.sym} 220 3630 0 0 {name=X134}
C {decoder/decoder_cell_0.sym} 340 3790 0 0 {name=X135}
C {decoder/decoder_cell_0.sym} 220 3790 0 0 {name=X136}
C {decoder/decoder_cell_0.sym} 700 2670 0 1 {name=X137}
C {decoder/decoder_cell_0.sym} 700 2830 0 1 {name=X138}
C {decoder/decoder_cell_0.sym} 700 2990 0 1 {name=X139}
C {decoder/decoder_cell_0.sym} 700 3150 0 1 {name=X140}
C {decoder/decoder_cell_0.sym} 700 3310 0 1 {name=X141}
C {decoder/decoder_cell_0.sym} 700 3470 0 1 {name=X142}
C {decoder/decoder_cell_0.sym} 700 3630 0 1 {name=X143}
C {decoder/decoder_cell_0.sym} 700 3790 0 1 {name=X144}
C {decoder/decoder_cell_0.sym} 460 3950 0 0 {name=X145}
C {decoder/decoder_cell_0.sym} 340 3950 0 0 {name=X146}
C {decoder/decoder_cell_0.sym} 220 3950 0 0 {name=X147}
C {decoder/decoder_cell_0.sym} 460 4110 0 0 {name=X148}
C {decoder/decoder_cell_0.sym} 340 4110 0 0 {name=X149}
C {decoder/decoder_cell_0.sym} 220 4110 0 0 {name=X150}
C {decoder/decoder_cell_0.sym} 460 4270 0 0 {name=X151}
C {decoder/decoder_cell_0.sym} 340 4270 0 0 {name=X152}
C {decoder/decoder_cell_0.sym} 220 4270 0 0 {name=X153}
C {decoder/decoder_cell_0.sym} 460 4430 0 0 {name=X154}
C {decoder/decoder_cell_0.sym} 340 4430 0 0 {name=X155}
C {decoder/decoder_cell_0.sym} 220 4430 0 0 {name=X156}
C {decoder/decoder_cell_0.sym} 460 4590 0 0 {name=X157}
C {decoder/decoder_cell_0.sym} 340 4590 0 0 {name=X158}
C {decoder/decoder_cell_0.sym} 220 4590 0 0 {name=X159}
C {decoder/decoder_cell_0.sym} 460 4750 0 0 {name=X160}
C {decoder/decoder_cell_0.sym} 340 4750 0 0 {name=X161}
C {decoder/decoder_cell_0.sym} 220 4750 0 0 {name=X162}
C {decoder/decoder_cell_0.sym} 460 4910 0 0 {name=X163}
C {decoder/decoder_cell_0.sym} 340 4910 0 0 {name=X164}
C {decoder/decoder_cell_0.sym} 220 4910 0 0 {name=X165}
C {decoder/decoder_cell_0.sym} 460 5070 0 0 {name=X166}
C {decoder/decoder_cell_0.sym} 340 5070 0 0 {name=X167}
C {decoder/decoder_cell_0.sym} 220 5070 0 0 {name=X168}
C {decoder/decoder_cell_0.sym} 820 3950 0 1 {name=X169}
C {decoder/decoder_cell_0.sym} 820 4110 0 1 {name=X170}
C {decoder/decoder_cell_0.sym} 820 4270 0 1 {name=X171}
C {decoder/decoder_cell_0.sym} 820 4430 0 1 {name=X172}
C {decoder/decoder_cell_0.sym} 700 3950 0 0 {name=X173}
C {decoder/decoder_cell_0.sym} 820 3950 0 0 {name=X174}
C {decoder/decoder_cell_0.sym} 700 4110 0 0 {name=X175}
C {decoder/decoder_cell_0.sym} 1060 4110 0 1 {name=X176}
C {decoder/decoder_cell_0.sym} 1060 4270 0 1 {name=X177}
C {decoder/decoder_cell_0.sym} 940 4270 0 1 {name=X178}
C {decoder/decoder_cell_0.sym} 940 4430 0 1 {name=X179}
C {decoder/decoder_cell_0.sym} 820 4430 0 0 {name=X180}
C {decoder/decoder_cell_0.sym} 580 4590 0 0 {name=X181}
C {decoder/decoder_cell_0.sym} 580 4750 0 0 {name=X182}
C {decoder/decoder_cell_0.sym} 580 4910 0 0 {name=X183}
C {decoder/decoder_cell_0.sym} 580 5070 0 0 {name=X184}
C {decoder/decoder_cell_0.sym} 940 4590 0 1 {name=X185}
C {decoder/decoder_cell_0.sym} 820 4590 0 0 {name=X186}
C {decoder/decoder_cell_0.sym} 940 4750 0 1 {name=X187}
C {decoder/decoder_cell_0.sym} 1060 4750 0 1 {name=X188}
C {decoder/decoder_cell_0.sym} 700 4910 0 0 {name=X189}
C {decoder/decoder_cell_0.sym} 1060 4910 0 1 {name=X190}
C {decoder/decoder_cell_0.sym} 700 5070 0 0 {name=X191}
C {decoder/decoder_cell_0.sym} 820 5070 0 0 {name=X192}
C {decoder/decoder_cell_0.sym} 460 5230 0 1 {name=X193}
C {decoder/decoder_cell_0.sym} 460 5390 0 1 {name=X194}
C {decoder/decoder_cell_0.sym} 460 5550 0 1 {name=X195}
C {decoder/decoder_cell_0.sym} 460 5710 0 1 {name=X196}
C {decoder/decoder_cell_0.sym} 460 5870 0 1 {name=X197}
C {decoder/decoder_cell_0.sym} 460 6030 0 1 {name=X198}
C {decoder/decoder_cell_0.sym} 460 6190 0 1 {name=X199}
C {decoder/decoder_cell_0.sym} 460 6350 0 1 {name=X200}
C {decoder/decoder_cell_0.sym} 700 5230 0 0 {name=X201}
C {decoder/decoder_cell_0.sym} 820 5230 0 0 {name=X202}
C {decoder/decoder_cell_0.sym} 700 5390 0 0 {name=X203}
C {decoder/decoder_cell_0.sym} 1060 5390 0 1 {name=X204}
C {decoder/decoder_cell_0.sym} 1060 5550 0 1 {name=X205}
C {decoder/decoder_cell_0.sym} 940 5550 0 1 {name=X206}
C {decoder/decoder_cell_0.sym} 940 5710 0 1 {name=X207}
C {decoder/decoder_cell_0.sym} 820 5710 0 0 {name=X208}
C {decoder/decoder_cell_0.sym} 580 5230 0 0 {name=X209}
C {decoder/decoder_cell_0.sym} 460 5230 0 0 {name=X210}
C {decoder/decoder_cell_0.sym} 340 5230 0 0 {name=X211}
C {decoder/decoder_cell_0.sym} 580 5390 0 0 {name=X212}
C {decoder/decoder_cell_0.sym} 460 5390 0 0 {name=X213}
C {decoder/decoder_cell_0.sym} 340 5390 0 0 {name=X214}
C {decoder/decoder_cell_0.sym} 580 5550 0 0 {name=X215}
C {decoder/decoder_cell_0.sym} 460 5550 0 0 {name=X216}
C {decoder/decoder_cell_0.sym} 340 5550 0 0 {name=X217}
C {decoder/decoder_cell_0.sym} 580 5710 0 0 {name=X218}
C {decoder/decoder_cell_0.sym} 460 5710 0 0 {name=X219}
C {decoder/decoder_cell_0.sym} 340 5710 0 0 {name=X220}
C {decoder/decoder_cell_0.sym} 460 5870 0 0 {name=X221}
C {decoder/decoder_cell_0.sym} 340 5870 0 0 {name=X222}
C {decoder/decoder_cell_0.sym} 460 6030 0 0 {name=X223}
C {decoder/decoder_cell_0.sym} 340 6030 0 0 {name=X224}
C {decoder/decoder_cell_0.sym} 460 6190 0 0 {name=X225}
C {decoder/decoder_cell_0.sym} 340 6190 0 0 {name=X226}
C {decoder/decoder_cell_0.sym} 460 6350 0 0 {name=X227}
C {decoder/decoder_cell_0.sym} 340 6350 0 0 {name=X228}
C {decoder/decoder_cell_0.sym} 820 5870 0 1 {name=X229}
C {decoder/decoder_cell_0.sym} 940 5870 0 1 {name=X230}
C {decoder/decoder_cell_0.sym} 820 5870 0 0 {name=X231}
C {decoder/decoder_cell_0.sym} 820 6030 0 1 {name=X232}
C {decoder/decoder_cell_0.sym} 940 6030 0 1 {name=X233}
C {decoder/decoder_cell_0.sym} 1060 6030 0 1 {name=X234}
C {decoder/decoder_cell_0.sym} 820 6190 0 1 {name=X235}
C {decoder/decoder_cell_0.sym} 700 6190 0 0 {name=X236}
C {decoder/decoder_cell_0.sym} 1060 6190 0 1 {name=X237}
C {decoder/decoder_cell_0.sym} 820 6350 0 1 {name=X238}
C {decoder/decoder_cell_0.sym} 700 6350 0 0 {name=X239}
C {decoder/decoder_cell_0.sym} 820 6350 0 0 {name=X240}
C {decoder/decoder_cell_0.sym} 460 6510 0 1 {name=X241}
C {decoder/decoder_cell_0.sym} 460 6670 0 1 {name=X242}
C {decoder/decoder_cell_0.sym} 460 6830 0 1 {name=X243}
C {decoder/decoder_cell_0.sym} 460 6990 0 1 {name=X244}
C {decoder/decoder_cell_0.sym} 460 7150 0 1 {name=X245}
C {decoder/decoder_cell_0.sym} 460 7310 0 1 {name=X246}
C {decoder/decoder_cell_0.sym} 460 7470 0 1 {name=X247}
C {decoder/decoder_cell_0.sym} 460 7630 0 1 {name=X248}
C {decoder/decoder_cell_0.sym} 460 7790 0 1 {name=X249}
C {decoder/decoder_cell_0.sym} 460 7950 0 1 {name=X250}
C {decoder/decoder_cell_0.sym} 460 8110 0 1 {name=X251}
C {decoder/decoder_cell_0.sym} 460 8270 0 1 {name=X252}
C {decoder/decoder_cell_0.sym} 460 8430 0 1 {name=X253}
C {decoder/decoder_cell_0.sym} 460 8590 0 1 {name=X254}
C {decoder/decoder_cell_0.sym} 460 8750 0 1 {name=X255}
C {decoder/decoder_cell_0.sym} 460 8910 0 1 {name=X256}
C {decoder/decoder_cell_0.sym} 460 9070 0 1 {name=X257}
C {decoder/decoder_cell_0.sym} 460 9230 0 1 {name=X258}
C {decoder/decoder_cell_0.sym} 460 9390 0 1 {name=X259}
C {decoder/decoder_cell_0.sym} 460 9550 0 1 {name=X260}
C {decoder/decoder_cell_0.sym} 460 9710 0 1 {name=X261}
C {decoder/decoder_cell_0.sym} 460 9870 0 1 {name=X262}
C {decoder/decoder_cell_0.sym} 460 10030 0 1 {name=X263}
C {decoder/decoder_cell_0.sym} 460 10190 0 1 {name=X264}
C {decoder/decoder_cell_0.sym} 340 6510 0 0 {name=X265}
C {decoder/decoder_cell_0.sym} 340 6670 0 0 {name=X266}
C {decoder/decoder_cell_0.sym} 340 6830 0 0 {name=X267}
C {decoder/decoder_cell_0.sym} 340 6990 0 0 {name=X268}
C {decoder/decoder_cell_0.sym} 340 7150 0 0 {name=X269}
C {decoder/decoder_cell_0.sym} 340 7310 0 0 {name=X270}
C {decoder/decoder_cell_0.sym} 340 7470 0 0 {name=X271}
C {decoder/decoder_cell_0.sym} 340 7630 0 0 {name=X272}
C {decoder/decoder_cell_0.sym} 700 6510 0 1 {name=X273}
C {decoder/decoder_cell_0.sym} 700 6670 0 1 {name=X274}
C {decoder/decoder_cell_0.sym} 700 6830 0 1 {name=X275}
C {decoder/decoder_cell_0.sym} 700 6990 0 1 {name=X276}
C {decoder/decoder_cell_0.sym} 700 7150 0 1 {name=X277}
C {decoder/decoder_cell_0.sym} 700 7310 0 1 {name=X278}
C {decoder/decoder_cell_0.sym} 700 7470 0 1 {name=X279}
C {decoder/decoder_cell_0.sym} 700 7630 0 1 {name=X280}
C {decoder/decoder_cell_0.sym} 820 6510 0 1 {name=X281}
C {decoder/decoder_cell_0.sym} 820 6670 0 1 {name=X282}
C {decoder/decoder_cell_0.sym} 820 6830 0 1 {name=X283}
C {decoder/decoder_cell_0.sym} 820 6990 0 1 {name=X284}
C {decoder/decoder_cell_0.sym} 700 6510 0 0 {name=X285}
C {decoder/decoder_cell_0.sym} 820 6510 0 0 {name=X286}
C {decoder/decoder_cell_0.sym} 700 6670 0 0 {name=X287}
C {decoder/decoder_cell_0.sym} 1060 6670 0 1 {name=X288}
C {decoder/decoder_cell_0.sym} 1060 6830 0 1 {name=X289}
C {decoder/decoder_cell_0.sym} 940 6830 0 1 {name=X290}
C {decoder/decoder_cell_0.sym} 940 6990 0 1 {name=X291}
C {decoder/decoder_cell_0.sym} 820 6990 0 0 {name=X292}
C {decoder/decoder_cell_0.sym} 580 7150 0 0 {name=X293}
C {decoder/decoder_cell_0.sym} 580 7310 0 0 {name=X294}
C {decoder/decoder_cell_0.sym} 580 7470 0 0 {name=X295}
C {decoder/decoder_cell_0.sym} 580 7630 0 0 {name=X296}
C {decoder/decoder_cell_0.sym} 940 7150 0 1 {name=X297}
C {decoder/decoder_cell_0.sym} 820 7150 0 0 {name=X298}
C {decoder/decoder_cell_0.sym} 940 7310 0 1 {name=X299}
C {decoder/decoder_cell_0.sym} 1060 7310 0 1 {name=X300}
C {decoder/decoder_cell_0.sym} 700 7470 0 0 {name=X301}
C {decoder/decoder_cell_0.sym} 1060 7470 0 1 {name=X302}
C {decoder/decoder_cell_0.sym} 700 7630 0 0 {name=X303}
C {decoder/decoder_cell_0.sym} 820 7630 0 0 {name=X304}
C {decoder/decoder_cell_0.sym} 700 7790 0 0 {name=X305}
C {decoder/decoder_cell_0.sym} 820 7790 0 0 {name=X306}
C {decoder/decoder_cell_0.sym} 700 7950 0 0 {name=X307}
C {decoder/decoder_cell_0.sym} 1060 7950 0 1 {name=X308}
C {decoder/decoder_cell_0.sym} 1060 8110 0 1 {name=X309}
C {decoder/decoder_cell_0.sym} 940 8110 0 1 {name=X310}
C {decoder/decoder_cell_0.sym} 940 8270 0 1 {name=X311}
C {decoder/decoder_cell_0.sym} 820 8270 0 0 {name=X312}
C {decoder/decoder_cell_0.sym} 580 7790 0 0 {name=X313}
C {decoder/decoder_cell_0.sym} 580 7950 0 0 {name=X314}
C {decoder/decoder_cell_0.sym} 580 8110 0 0 {name=X315}
C {decoder/decoder_cell_0.sym} 580 8270 0 0 {name=X316}
C {decoder/decoder_cell_0.sym} 820 8430 0 1 {name=X317}
C {decoder/decoder_cell_0.sym} 940 8430 0 1 {name=X318}
C {decoder/decoder_cell_0.sym} 820 8430 0 0 {name=X319}
C {decoder/decoder_cell_0.sym} 820 8590 0 1 {name=X320}
C {decoder/decoder_cell_0.sym} 940 8590 0 1 {name=X321}
C {decoder/decoder_cell_0.sym} 1060 8590 0 1 {name=X322}
C {decoder/decoder_cell_0.sym} 820 8750 0 1 {name=X323}
C {decoder/decoder_cell_0.sym} 700 8750 0 0 {name=X324}
C {decoder/decoder_cell_0.sym} 1060 8750 0 1 {name=X325}
C {decoder/decoder_cell_0.sym} 820 8910 0 1 {name=X326}
C {decoder/decoder_cell_0.sym} 700 8910 0 0 {name=X327}
C {decoder/decoder_cell_0.sym} 820 8910 0 0 {name=X328}
C {decoder/decoder_cell_0.sym} 340 7790 0 0 {name=X329}
C {decoder/decoder_cell_0.sym} 340 7950 0 0 {name=X330}
C {decoder/decoder_cell_0.sym} 340 8110 0 0 {name=X331}
C {decoder/decoder_cell_0.sym} 340 8270 0 0 {name=X332}
C {decoder/decoder_cell_0.sym} 340 8430 0 0 {name=X333}
C {decoder/decoder_cell_0.sym} 340 8590 0 0 {name=X334}
C {decoder/decoder_cell_0.sym} 340 8750 0 0 {name=X335}
C {decoder/decoder_cell_0.sym} 340 8910 0 0 {name=X336}
C {decoder/decoder_cell_0.sym} 700 7790 0 1 {name=X337}
C {decoder/decoder_cell_0.sym} 700 7950 0 1 {name=X338}
C {decoder/decoder_cell_0.sym} 700 8110 0 1 {name=X339}
C {decoder/decoder_cell_0.sym} 700 8270 0 1 {name=X340}
C {decoder/decoder_cell_0.sym} 700 8430 0 1 {name=X341}
C {decoder/decoder_cell_0.sym} 700 8590 0 1 {name=X342}
C {decoder/decoder_cell_0.sym} 700 8750 0 1 {name=X343}
C {decoder/decoder_cell_0.sym} 700 8910 0 1 {name=X344}
C {decoder/decoder_cell_0.sym} 460 9070 0 0 {name=X393}
C {decoder/decoder_cell_0.sym} 340 9070 0 0 {name=X394}
C {decoder/decoder_cell_0.sym} 460 9230 0 0 {name=X395}
C {decoder/decoder_cell_0.sym} 340 9230 0 0 {name=X396}
C {decoder/decoder_cell_0.sym} 460 9390 0 0 {name=X397}
C {decoder/decoder_cell_0.sym} 340 9390 0 0 {name=X398}
C {decoder/decoder_cell_0.sym} 460 9550 0 0 {name=X399}
C {decoder/decoder_cell_0.sym} 340 9550 0 0 {name=X400}
C {decoder/decoder_cell_0.sym} 460 9710 0 0 {name=X401}
C {decoder/decoder_cell_0.sym} 340 9710 0 0 {name=X402}
C {decoder/decoder_cell_0.sym} 460 9870 0 0 {name=X403}
C {decoder/decoder_cell_0.sym} 340 9870 0 0 {name=X404}
C {decoder/decoder_cell_0.sym} 460 10030 0 0 {name=X405}
C {decoder/decoder_cell_0.sym} 340 10030 0 0 {name=X406}
C {decoder/decoder_cell_0.sym} 460 10190 0 0 {name=X407}
C {decoder/decoder_cell_0.sym} 340 10190 0 0 {name=X408}
C {decoder/decoder_cell_0.sym} 820 9070 0 1 {name=X409}
C {decoder/decoder_cell_0.sym} 820 9230 0 1 {name=X410}
C {decoder/decoder_cell_0.sym} 820 9390 0 1 {name=X411}
C {decoder/decoder_cell_0.sym} 820 9550 0 1 {name=X412}
C {decoder/decoder_cell_0.sym} 700 9070 0 0 {name=X413}
C {decoder/decoder_cell_0.sym} 820 9070 0 0 {name=X414}
C {decoder/decoder_cell_0.sym} 700 9230 0 0 {name=X415}
C {decoder/decoder_cell_0.sym} 1060 9230 0 1 {name=X416}
C {decoder/decoder_cell_0.sym} 1060 9390 0 1 {name=X417}
C {decoder/decoder_cell_0.sym} 940 9390 0 1 {name=X418}
C {decoder/decoder_cell_0.sym} 940 9550 0 1 {name=X419}
C {decoder/decoder_cell_0.sym} 820 9550 0 0 {name=X420}
C {decoder/decoder_cell_0.sym} 580 9710 0 0 {name=X421}
C {decoder/decoder_cell_0.sym} 580 9870 0 0 {name=X422}
C {decoder/decoder_cell_0.sym} 580 10030 0 0 {name=X423}
C {decoder/decoder_cell_0.sym} 580 10190 0 0 {name=X424}
C {decoder/decoder_cell_0.sym} 940 9710 0 1 {name=X425}
C {decoder/decoder_cell_0.sym} 820 9710 0 0 {name=X426}
C {decoder/decoder_cell_0.sym} 940 9870 0 1 {name=X427}
C {decoder/decoder_cell_0.sym} 1060 9870 0 1 {name=X428}
C {decoder/decoder_cell_0.sym} 700 10030 0 0 {name=X429}
C {decoder/decoder_cell_0.sym} 1060 10030 0 1 {name=X430}
C {decoder/decoder_cell_0.sym} 700 10190 0 0 {name=X431}
C {decoder/decoder_cell_0.sym} 820 10190 0 0 {name=X432}
C {decoder/out_peripheral_cell.sym} 520 280 0 0 {name=X345}
C {decoder/out_peripheral_cell.sym} 520 120 0 0 {name=X346}
C {decoder/out_peripheral_cell.sym} 520 440 0 0 {name=X347}
C {decoder/out_peripheral_cell.sym} 520 600 0 0 {name=X348}
C {decoder/out_peripheral_cell.sym} 520 920 0 0 {name=X349}
C {decoder/out_peripheral_cell.sym} 520 760 0 0 {name=X350}
C {decoder/out_peripheral_cell.sym} 520 1080 0 0 {name=X351}
C {decoder/out_peripheral_cell.sym} 520 1240 0 0 {name=X352}
C {decoder/out_peripheral_cell.sym} 520 1560 0 0 {name=X353}
C {decoder/out_peripheral_cell.sym} 520 1400 0 0 {name=X354}
C {decoder/out_peripheral_cell.sym} 520 1720 0 0 {name=X355}
C {decoder/out_peripheral_cell.sym} 520 1880 0 0 {name=X356}
C {decoder/out_peripheral_cell.sym} 520 2200 0 0 {name=X357}
C {decoder/out_peripheral_cell.sym} 520 2040 0 0 {name=X358}
C {decoder/out_peripheral_cell.sym} 520 2360 0 0 {name=X359}
C {decoder/out_peripheral_cell.sym} 520 2520 0 0 {name=X360}
C {decoder/out_peripheral_cell.sym} 520 2840 0 0 {name=X361}
C {decoder/out_peripheral_cell.sym} 520 2680 0 0 {name=X362}
C {decoder/out_peripheral_cell.sym} 520 3000 0 0 {name=X363}
C {decoder/out_peripheral_cell.sym} 520 3160 0 0 {name=X364}
C {decoder/out_peripheral_cell.sym} 520 3480 0 0 {name=X365}
C {decoder/out_peripheral_cell.sym} 520 3320 0 0 {name=X366}
C {decoder/out_peripheral_cell.sym} 520 3640 0 0 {name=X367}
C {decoder/out_peripheral_cell.sym} 520 3800 0 0 {name=X368}
C {decoder/out_peripheral_cell.sym} 520 4120 0 0 {name=X369}
C {decoder/out_peripheral_cell.sym} 520 3960 0 0 {name=X370}
C {decoder/out_peripheral_cell.sym} 520 4280 0 0 {name=X371}
C {decoder/out_peripheral_cell.sym} 520 4440 0 0 {name=X372}
C {decoder/out_peripheral_cell.sym} 520 4760 0 0 {name=X373}
C {decoder/out_peripheral_cell.sym} 520 4600 0 0 {name=X374}
C {decoder/out_peripheral_cell.sym} 520 4920 0 0 {name=X375}
C {decoder/out_peripheral_cell.sym} 520 5080 0 0 {name=X376}
C {decoder/out_peripheral_cell.sym} 520 5240 0 0 {name=X377}
C {decoder/out_peripheral_cell.sym} 520 5400 0 0 {name=X378}
C {decoder/out_peripheral_cell.sym} 520 5720 0 0 {name=X379}
C {decoder/out_peripheral_cell.sym} 520 5560 0 0 {name=X380}
C {decoder/out_peripheral_cell.sym} 520 5880 0 0 {name=X381}
C {decoder/out_peripheral_cell.sym} 520 6040 0 0 {name=X382}
C {decoder/out_peripheral_cell.sym} 520 6360 0 0 {name=X383}
C {decoder/out_peripheral_cell.sym} 520 6200 0 0 {name=X384}
C {decoder/out_peripheral_cell.sym} 520 6520 0 0 {name=X385}
C {decoder/out_peripheral_cell.sym} 520 6680 0 0 {name=X386}
C {decoder/out_peripheral_cell.sym} 520 7000 0 0 {name=X387}
C {decoder/out_peripheral_cell.sym} 520 6840 0 0 {name=X388}
C {decoder/out_peripheral_cell.sym} 520 7160 0 0 {name=X389}
C {decoder/out_peripheral_cell.sym} 520 7320 0 0 {name=X390}
C {decoder/out_peripheral_cell.sym} 520 7640 0 0 {name=X391}
C {decoder/out_peripheral_cell.sym} 520 7480 0 0 {name=X392}
C {decoder/out_peripheral_cell.sym} 520 7800 0 0 {name=X433}
C {decoder/out_peripheral_cell.sym} 520 7960 0 0 {name=X434}
C {decoder/out_peripheral_cell.sym} 520 8280 0 0 {name=X435}
C {decoder/out_peripheral_cell.sym} 520 8120 0 0 {name=X436}
C {decoder/out_peripheral_cell.sym} 520 8440 0 0 {name=X437}
C {decoder/out_peripheral_cell.sym} 520 8600 0 0 {name=X438}
C {decoder/out_peripheral_cell.sym} 520 8760 0 0 {name=X439}
C {decoder/out_peripheral_cell.sym} 520 8920 0 0 {name=X440}
C {decoder/out_peripheral_cell.sym} 520 9240 0 0 {name=X441}
C {decoder/out_peripheral_cell.sym} 520 9080 0 0 {name=X442}
C {decoder/out_peripheral_cell.sym} 520 9400 0 0 {name=X443}
C {decoder/out_peripheral_cell.sym} 520 9560 0 0 {name=X444}
C {decoder/out_peripheral_cell.sym} 520 9880 0 0 {name=X445}
C {decoder/out_peripheral_cell.sym} 520 9720 0 0 {name=X446}
C {decoder/out_peripheral_cell.sym} 520 10040 0 0 {name=X447}
C {decoder/out_peripheral_cell.sym} 520 10200 0 0 {name=X448}
C {decoder/in_peripheral_cell.sym} -230 180 0 0 {name=X449}
C {decoder/in_peripheral_cell.sym} -230 340 0 0 {name=X450}
C {decoder/in_peripheral_cell.sym} -230 500 0 0 {name=X451}
C {decoder/in_peripheral_cell.sym} -230 660 0 0 {name=X452}
C {decoder/in_peripheral_cell.sym} -230 820 0 0 {name=X453}
C {decoder/in_peripheral_cell.sym} -230 980 0 0 {name=X454}
C {decoder/in_peripheral_cell.sym} -230 1140 0 0 {name=X455}
C {decoder/in_peripheral_cell.sym} -230 1300 0 0 {name=X456}
C {decoder/in_peripheral_cell.sym} -230 1460 0 0 {name=X457}
C {decoder/in_peripheral_cell.sym} -230 1620 0 0 {name=X458}
C {decoder/in_peripheral_cell.sym} -230 1780 0 0 {name=X459}
C {decoder/in_peripheral_cell.sym} -230 1940 0 0 {name=X460}
C {decoder/in_peripheral_cell.sym} -230 2100 0 0 {name=X461}
C {decoder/in_peripheral_cell.sym} -230 2260 0 0 {name=X462}
C {decoder/in_peripheral_cell.sym} -230 2420 0 0 {name=X463}
C {decoder/in_peripheral_cell.sym} -230 2580 0 0 {name=X464}
C {decoder/in_peripheral_cell.sym} -230 2740 0 0 {name=X465}
C {decoder/in_peripheral_cell.sym} -230 2900 0 0 {name=X466}
C {decoder/in_peripheral_cell.sym} -230 3060 0 0 {name=X467}
C {decoder/in_peripheral_cell.sym} -230 3220 0 0 {name=X468}
C {decoder/in_peripheral_cell.sym} -230 3380 0 0 {name=X469}
C {decoder/in_peripheral_cell.sym} -230 3540 0 0 {name=X470}
C {decoder/in_peripheral_cell.sym} -230 3700 0 0 {name=X471}
C {decoder/in_peripheral_cell.sym} -230 3860 0 0 {name=X472}
C {decoder/in_peripheral_cell.sym} -230 4020 0 0 {name=X473}
C {decoder/in_peripheral_cell.sym} -230 4180 0 0 {name=X474}
C {decoder/in_peripheral_cell.sym} -230 4340 0 0 {name=X475}
C {decoder/in_peripheral_cell.sym} -230 4500 0 0 {name=X476}
C {decoder/in_peripheral_cell.sym} -230 4660 0 0 {name=X477}
C {decoder/in_peripheral_cell.sym} -230 4820 0 0 {name=X478}
C {decoder/in_peripheral_cell.sym} -230 4980 0 0 {name=X479}
C {decoder/in_peripheral_cell.sym} -230 5140 0 0 {name=X480}
C {decoder/in_peripheral_cell.sym} -230 5300 0 0 {name=X481}
C {decoder/in_peripheral_cell.sym} -230 5460 0 0 {name=X482}
C {decoder/in_peripheral_cell.sym} -230 5620 0 0 {name=X483}
C {decoder/in_peripheral_cell.sym} -230 5780 0 0 {name=X484}
C {decoder/in_peripheral_cell.sym} -230 5940 0 0 {name=X485}
C {decoder/in_peripheral_cell.sym} -230 6100 0 0 {name=X486}
C {decoder/in_peripheral_cell.sym} -230 6260 0 0 {name=X487}
C {decoder/in_peripheral_cell.sym} -230 6420 0 0 {name=X488}
C {decoder/in_peripheral_cell.sym} -230 6580 0 0 {name=X489}
C {decoder/in_peripheral_cell.sym} -230 6740 0 0 {name=X490}
C {decoder/in_peripheral_cell.sym} -230 6900 0 0 {name=X491}
C {decoder/in_peripheral_cell.sym} -230 7060 0 0 {name=X492}
C {decoder/in_peripheral_cell.sym} -230 7220 0 0 {name=X493}
C {decoder/in_peripheral_cell.sym} -230 7380 0 0 {name=X494}
C {decoder/in_peripheral_cell.sym} -230 7540 0 0 {name=X495}
C {decoder/in_peripheral_cell.sym} -230 7700 0 0 {name=X496}
C {decoder/in_peripheral_cell.sym} -230 7860 0 0 {name=X497}
C {decoder/in_peripheral_cell.sym} -230 8020 0 0 {name=X498}
C {decoder/in_peripheral_cell.sym} -230 8180 0 0 {name=X499}
C {decoder/in_peripheral_cell.sym} -230 8340 0 0 {name=X500}
C {decoder/in_peripheral_cell.sym} -230 8500 0 0 {name=X501}
C {decoder/in_peripheral_cell.sym} -230 8660 0 0 {name=X502}
C {decoder/in_peripheral_cell.sym} -230 8820 0 0 {name=X503}
C {decoder/in_peripheral_cell.sym} -230 8980 0 0 {name=X504}
C {decoder/in_peripheral_cell.sym} -230 9140 0 0 {name=X505}
C {decoder/in_peripheral_cell.sym} -230 9300 0 0 {name=X506}
C {decoder/in_peripheral_cell.sym} -230 9460 0 0 {name=X507}
C {decoder/in_peripheral_cell.sym} -230 9620 0 0 {name=X508}
C {decoder/in_peripheral_cell.sym} -230 9780 0 0 {name=X509}
C {decoder/in_peripheral_cell.sym} -230 9940 0 0 {name=X510}
C {decoder/in_peripheral_cell.sym} -230 10100 0 0 {name=X511}
C {decoder/in_peripheral_cell.sym} -230 10260 0 0 {name=X512}
C {decoder/bottom_peripheral_cell.sym} 130 10180 0 0 {name=X513}
C {decoder/bottom_peripheral_cell.sym} 250 10180 0 0 {name=X514}
C {decoder/bottom_peripheral_cell.sym} 370 10180 0 0 {name=X515}
C {decoder/bottom_peripheral_cell.sym} 490 10180 0 0 {name=X516}
C {decoder/bottom_peripheral_cell.sym} 610 10180 0 0 {name=X517}
C {decoder/bottom_peripheral_cell.sym} 730 10180 0 0 {name=X518}
C {devices/ipin.sym} 360 10310 3 0 {name=p3 lab=A5}
C {devices/ipin.sym} 480 10310 3 0 {name=p4 lab=A4}
C {devices/ipin.sym} 600 10310 3 0 {name=p5 lab=A3}
C {devices/ipin.sym} 720 10310 3 0 {name=p6 lab=A2}
C {devices/ipin.sym} 840 10310 3 0 {name=p7 lab=A1}
C {devices/ipin.sym} 960 10310 3 0 {name=p8 lab=A0}
C {devices/opin.sym} 1100 10100 0 0 {name=p9 lab=sel63}
C {devices/opin.sym} 1100 9940 0 0 {name=p10 lab=sel62}
C {devices/opin.sym} 1100 9780 0 0 {name=p11 lab=sel61}
C {devices/opin.sym} 1100 9620 0 0 {name=p12 lab=sel60}
C {devices/opin.sym} 1100 9460 0 0 {name=p13 lab=sel59}
C {devices/opin.sym} 1100 9300 0 0 {name=p14 lab=sel58}
C {devices/opin.sym} 1100 9140 0 0 {name=p15 lab=sel57}
C {devices/opin.sym} 1100 8980 0 0 {name=p16 lab=sel56}
C {devices/opin.sym} 1100 8820 0 0 {name=p17 lab=sel55}
C {devices/opin.sym} 1100 8660 0 0 {name=p18 lab=sel54}
C {devices/opin.sym} 1100 8500 0 0 {name=p19 lab=sel53}
C {devices/opin.sym} 1100 8340 0 0 {name=p20 lab=sel52}
C {devices/opin.sym} 1100 8180 0 0 {name=p21 lab=sel51}
C {devices/opin.sym} 1100 8020 0 0 {name=p22 lab=sel50}
C {devices/opin.sym} 1100 7860 0 0 {name=p23 lab=sel49}
C {devices/opin.sym} 1100 7700 0 0 {name=p24 lab=sel48}
C {devices/opin.sym} 1100 7540 0 0 {name=p25 lab=sel47}
C {devices/opin.sym} 1100 7380 0 0 {name=p26 lab=sel46}
C {devices/opin.sym} 1100 7220 0 0 {name=p27 lab=sel45}
C {devices/opin.sym} 1100 7060 0 0 {name=p28 lab=sel44}
C {devices/opin.sym} 1100 6900 0 0 {name=p29 lab=sel43}
C {devices/opin.sym} 1100 6740 0 0 {name=p30 lab=sel42}
C {devices/opin.sym} 1100 6580 0 0 {name=p31 lab=sel41}
C {devices/opin.sym} 1100 6420 0 0 {name=p32 lab=sel40}
C {devices/opin.sym} 1100 6260 0 0 {name=p33 lab=sel39}
C {devices/opin.sym} 1100 6100 0 0 {name=p34 lab=sel38}
C {devices/opin.sym} 1100 5940 0 0 {name=p35 lab=sel37}
C {devices/opin.sym} 1100 5780 0 0 {name=p36 lab=sel36}
C {devices/opin.sym} 1100 5620 0 0 {name=p37 lab=sel35}
C {devices/opin.sym} 1100 5460 0 0 {name=p38 lab=sel34}
C {devices/opin.sym} 1100 5300 0 0 {name=p39 lab=sel33}
C {devices/opin.sym} 1100 5140 0 0 {name=p40 lab=sel32}
C {devices/opin.sym} 1100 4980 0 0 {name=p41 lab=sel31}
C {devices/opin.sym} 1100 4820 0 0 {name=p42 lab=sel30}
C {devices/opin.sym} 1100 4660 0 0 {name=p43 lab=sel29}
C {devices/opin.sym} 1100 4500 0 0 {name=p44 lab=sel28}
C {devices/opin.sym} 1100 4340 0 0 {name=p45 lab=sel27}
C {devices/opin.sym} 1100 4180 0 0 {name=p46 lab=sel26}
C {devices/opin.sym} 1100 4020 0 0 {name=p47 lab=sel25}
C {devices/opin.sym} 1100 3860 0 0 {name=p48 lab=sel24}
C {devices/opin.sym} 1100 3700 0 0 {name=p49 lab=sel23}
C {devices/opin.sym} 1100 3540 0 0 {name=p50 lab=sel22}
C {devices/opin.sym} 1100 3380 0 0 {name=p51 lab=sel21}
C {devices/opin.sym} 1100 3220 0 0 {name=p52 lab=sel20}
C {devices/opin.sym} 1100 3060 0 0 {name=p53 lab=sel19}
C {devices/opin.sym} 1100 2900 0 0 {name=p54 lab=sel18}
C {devices/opin.sym} 1100 2740 0 0 {name=p55 lab=sel17}
C {devices/opin.sym} 1100 2580 0 0 {name=p56 lab=sel16}
C {devices/opin.sym} 1100 2420 0 0 {name=p57 lab=sel15}
C {devices/opin.sym} 1100 2260 0 0 {name=p58 lab=sel14}
C {devices/opin.sym} 1100 2100 0 0 {name=p59 lab=sel13}
C {devices/opin.sym} 1100 1940 0 0 {name=p60 lab=sel12}
C {devices/opin.sym} 1100 1780 0 0 {name=p61 lab=sel11}
C {devices/opin.sym} 1100 1620 0 0 {name=p62 lab=sel10}
C {devices/opin.sym} 1100 1460 0 0 {name=p63 lab=sel9}
C {devices/opin.sym} 1100 1300 0 0 {name=p64 lab=sel8}
C {devices/opin.sym} 1100 1140 0 0 {name=p65 lab=sel7}
C {devices/opin.sym} 1100 980 0 0 {name=p66 lab=sel6}
C {devices/opin.sym} 1100 820 0 0 {name=p67 lab=sel5}
C {devices/opin.sym} 1100 660 0 0 {name=p68 lab=sel4}
C {devices/opin.sym} 1100 500 0 0 {name=p69 lab=sel3}
C {devices/opin.sym} 1100 340 0 0 {name=p70 lab=sel2}
C {devices/opin.sym} 1100 180 0 0 {name=p71 lab=sel1}
C {devices/opin.sym} 1100 20 0 0 {name=p72 lab=sel0}
C {devices/vdd.sym} 240 -90 0 0 {name=l1 lab=VDD}
C {devices/gnd.sym} 220 10210 0 0 {name=l2 lab=GND}
