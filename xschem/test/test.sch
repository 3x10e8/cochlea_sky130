v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {inv/inv.sym} 2630 -1170 0 0 {name=X1}
