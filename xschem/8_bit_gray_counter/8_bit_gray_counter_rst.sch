v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -2250 -740 -1140 -740 { lab=Clk}
N -3670 -740 -3590 -740 { lab=Clk}
N -3590 -740 -2480 -740 { lab=Clk}
N -3160 -540 -3160 -520 { lab=Q0}
N -2800 -540 -2800 -520 { lab=Q1}
N -2480 -670 -2450 -670 { lab=qb2}
N -2440 -540 -2440 -520 { lab=Q2}
N -2140 -670 -2100 -670 { lab=qb3}
N -2090 -540 -2090 -520 { lab=Q3}
N -1740 -540 -1740 -520 { lab=Q4}
N -1370 -540 -1370 -520 { lab=Q5}
N -1090 -670 -1060 -670 { lab=qb6}
N -1050 -540 -1050 -520 { lab=Q6}
N -990 -760 -990 -740 { lab=Clk}
N -1350 -760 -1350 -740 { lab=Clk}
N -1710 -760 -1710 -740 { lab=Clk}
N -2070 -760 -2070 -740 { lab=Clk}
N -2430 -760 -2430 -740 { lab=Clk}
N -2790 -760 -2790 -740 { lab=Clk}
N -3460 -760 -3460 -740 { lab=Clk}
N -3150 -760 -3150 -740 { lab=Clk}
N -3670 -930 -3570 -930 { lab=EN}
N -3260 -1070 -3260 -930 { lab=qb0}
N -3260 -1070 -3040 -1070 { lab=qb0}
N -3040 -1040 -3040 -930 { lab=qb1}
N -2900 -1060 -2900 -930 { lab=#net1}
N -2900 -1060 -2680 -1060 { lab=#net1}
N -2680 -1030 -2680 -930 { lab=qb2}
N -2540 -1050 -2540 -930 { lab=#net2}
N -2540 -1050 -2320 -1050 { lab=#net2}
N -2320 -1020 -2320 -930 { lab=qb3}
N -2180 -1040 -2180 -930 { lab=#net3}
N -2180 -1040 -1960 -1040 { lab=#net3}
N -1960 -1010 -1960 -930 { lab=qb4}
N -1820 -1030 -1620 -1030 { lab=#net4}
N -1620 -1030 -1600 -1030 { lab=#net4}
N -1600 -1000 -1600 -930 { lab=qb5}
N -1820 -1030 -1820 -930 { lab=#net4}
N -1460 -1020 -1460 -930 { lab=#net5}
N -1460 -1020 -1240 -1020 { lab=#net5}
N -1240 -990 -1240 -930 { lab=qb6}
N -1100 -1010 -1100 -930 { lab=#net6}
N -880 -930 -830 -930 { lab=Q7}
N -830 -930 -830 -450 { lab=Q7}
N -3310 -930 -3310 -670 { lab=qb0}
N -3040 -930 -2990 -930 { lab=qb1}
N -2990 -930 -2990 -670 { lab=qb1}
N -2680 -930 -2630 -930 { lab=qb2}
N -2630 -930 -2630 -670 { lab=qb2}
N -2320 -930 -2270 -930 { lab=qb3}
N -2270 -930 -2270 -670 { lab=qb3}
N -2480 -740 -2250 -740 { lab=Clk}
N -1140 -740 -990 -740 { lab=Clk}
N -1960 -930 -1920 -930 { lab=qb4}
N -1920 -930 -1920 -670 { lab=qb4}
N -1600 -930 -1560 -930 { lab=qb5}
N -1560 -930 -1560 -670 { lab=qb5}
N -1240 -930 -1190 -930 { lab=qb6}
N -1190 -930 -1190 -670 { lab=qb6}
N -3310 -670 -3170 -670 { lab=qb0}
N -3140 -670 -2990 -670 { lab=qb1}
N -2990 -670 -2810 -670 { lab=qb1}
N -2780 -670 -2630 -670 { lab=qb2}
N -2630 -670 -2480 -670 { lab=qb2}
N -2420 -670 -2270 -670 { lab=qb3}
N -2270 -670 -2140 -670 { lab=qb3}
N -2070 -670 -1920 -670 { lab=qb4}
N -1920 -670 -1750 -670 { lab=qb4}
N -1720 -670 -1560 -670 { lab=qb5}
N -1560 -670 -1380 -670 { lab=qb5}
N -1350 -670 -1190 -670 { lab=qb6}
N -1190 -670 -1090 -670 { lab=qb6}
N -1030 -670 -830 -670 { lab=Q7}
N -2250 -740 -1140 -740 { lab=Clk}
N -3670 -740 -3590 -740 { lab=Clk}
N -3590 -740 -2480 -740 { lab=Clk}
N -3160 -540 -3160 -520 { lab=Q0}
N -2800 -540 -2800 -520 { lab=Q1}
N -2480 -670 -2450 -670 { lab=qb2}
N -2440 -540 -2440 -520 { lab=Q2}
N -2140 -670 -2100 -670 { lab=qb3}
N -2090 -540 -2090 -520 { lab=Q3}
N -1740 -540 -1740 -520 { lab=Q4}
N -1370 -540 -1370 -520 { lab=Q5}
N -1090 -670 -1060 -670 { lab=qb6}
N -1050 -540 -1050 -520 { lab=Q6}
N -990 -760 -990 -740 { lab=Clk}
N -1350 -760 -1350 -740 { lab=Clk}
N -1710 -760 -1710 -740 { lab=Clk}
N -2070 -760 -2070 -740 { lab=Clk}
N -2430 -760 -2430 -740 { lab=Clk}
N -2790 -760 -2790 -740 { lab=Clk}
N -3460 -760 -3460 -740 { lab=Clk}
N -3150 -760 -3150 -740 { lab=Clk}
N -3670 -930 -3570 -930 { lab=EN}
N -3260 -1070 -3260 -930 { lab=qb0}
N -3260 -1070 -3040 -1070 { lab=qb0}
N -3040 -1040 -3040 -930 { lab=qb1}
N -2900 -1060 -2900 -930 { lab=#net1}
N -2900 -1060 -2680 -1060 { lab=#net1}
N -2680 -1030 -2680 -930 { lab=qb2}
N -2540 -1050 -2540 -930 { lab=#net2}
N -2540 -1050 -2320 -1050 { lab=#net2}
N -2320 -1020 -2320 -930 { lab=qb3}
N -2180 -1040 -2180 -930 { lab=#net3}
N -2180 -1040 -1960 -1040 { lab=#net3}
N -1960 -1010 -1960 -930 { lab=qb4}
N -1820 -1030 -1620 -1030 { lab=#net4}
N -1620 -1030 -1600 -1030 { lab=#net4}
N -1600 -1000 -1600 -930 { lab=qb5}
N -1820 -1030 -1820 -930 { lab=#net4}
N -1460 -1020 -1460 -930 { lab=#net5}
N -1460 -1020 -1240 -1020 { lab=#net5}
N -1240 -990 -1240 -930 { lab=qb6}
N -1100 -1010 -1100 -930 { lab=#net6}
N -880 -930 -830 -930 { lab=Q7}
N -830 -930 -830 -450 { lab=Q7}
N -3310 -930 -3310 -670 { lab=qb0}
N -3040 -930 -2990 -930 { lab=qb1}
N -2990 -930 -2990 -670 { lab=qb1}
N -2680 -930 -2630 -930 { lab=qb2}
N -2630 -930 -2630 -670 { lab=qb2}
N -2320 -930 -2270 -930 { lab=qb3}
N -2270 -930 -2270 -670 { lab=qb3}
N -2480 -740 -2250 -740 { lab=Clk}
N -1140 -740 -990 -740 { lab=Clk}
N -1960 -930 -1920 -930 { lab=qb4}
N -1920 -930 -1920 -670 { lab=qb4}
N -1600 -930 -1560 -930 { lab=qb5}
N -1560 -930 -1560 -670 { lab=qb5}
N -1240 -930 -1190 -930 { lab=qb6}
N -1190 -930 -1190 -670 { lab=qb6}
N -3310 -670 -3170 -670 { lab=qb0}
N -3140 -670 -2990 -670 { lab=qb1}
N -2990 -670 -2810 -670 { lab=qb1}
N -2780 -670 -2630 -670 { lab=qb2}
N -2630 -670 -2480 -670 { lab=qb2}
N -2420 -670 -2270 -670 { lab=qb3}
N -2270 -670 -2140 -670 { lab=qb3}
N -2070 -670 -1920 -670 { lab=qb4}
N -1920 -670 -1750 -670 { lab=qb4}
N -1720 -670 -1560 -670 { lab=qb5}
N -1560 -670 -1380 -670 { lab=qb5}
N -1350 -670 -1190 -670 { lab=qb6}
N -1190 -670 -1090 -670 { lab=qb6}
N -1030 -670 -830 -670 { lab=Q7}
N -3350 -930 -3310 -930 { lab=qb0}
N -3310 -930 -3260 -930 { lab=qb0}
N -3660 -700 -1100 -700 { lab=Clk}
N -1100 -830 -1100 -700 { lab=Clk}
N -1460 -830 -1460 -700 { lab=Clk}
N -1820 -830 -1820 -700 { lab=Clk}
N -2180 -830 -2180 -700 { lab=Clk}
N -2540 -830 -2540 -700 { lab=Clk}
N -2900 -830 -2900 -700 { lab=Clk}
N -3260 -830 -3260 -700 { lab=Clk}
N -3570 -830 -3570 -700 { lab=Clk}
N -3670 -700 -3660 -700 {}
C {and_gate/and_gate.sym} -3540 -570 0 0 {name=X10}
C {and_gate/and_gate.sym} -3180 -560 0 0 {name=X11}
C {and_gate/and_gate.sym} -2820 -550 0 0 {name=X12}
C {and_gate/and_gate.sym} -2460 -540 0 0 {name=X13}
C {and_gate/and_gate.sym} -2100 -530 0 0 {name=X14}
C {and_gate/and_gate.sym} -1740 -520 0 0 {name=X15}
C {exor_gate/exor_gate.sym} -3060 -1180 3 1 {name=X16}
C {exor_gate/exor_gate.sym} -2700 -1180 3 1 {name=X17}
C {exor_gate/exor_gate.sym} -2340 -1180 3 1 {name=X18}
C {exor_gate/exor_gate.sym} -1990 -1180 3 1 {name=X19}
C {exor_gate/exor_gate.sym} -1640 -1180 3 1 {name=X20}
C {exor_gate/exor_gate.sym} -1270 -1180 3 1 {name=X21}
C {exor_gate/exor_gate.sym} -950 -1180 3 1 {name=X22}
C {devices/ipin.sym} -3660 -740 0 0 {name=p1 lab=Clk}
C {devices/ipin.sym} -3660 -930 0 0 {name=p2 lab=EN}
C {devices/opin.sym} -3160 -530 1 0 {name=p3 lab=Q0}
C {devices/opin.sym} -2800 -530 1 0 {name=p4 lab=Q1}
C {devices/opin.sym} -2440 -530 1 0 {name=p5 lab=Q2}
C {devices/opin.sym} -2090 -530 1 0 {name=p6 lab=Q3}
C {devices/opin.sym} -1740 -530 1 0 {name=p7 lab=Q4}
C {devices/opin.sym} -1370 -530 1 0 {name=p8 lab=Q5}
C {devices/opin.sym} -1050 -530 1 0 {name=p9 lab=Q6}
C {devices/opin.sym} -830 -460 1 0 {name=p10 lab=Q7}
C {devices/lab_pin.sym} -3310 -670 3 0 {name=l1 sig_type=std_logic lab=qb0}
C {devices/lab_pin.sym} -2990 -670 3 0 {name=l2 sig_type=std_logic lab=qb1}
C {devices/lab_pin.sym} -2630 -670 3 0 {name=l3 sig_type=std_logic lab=qb2}
C {devices/lab_pin.sym} -2270 -670 3 0 {name=l4 sig_type=std_logic lab=qb3}
C {devices/lab_pin.sym} -1920 -670 3 0 {name=l5 sig_type=std_logic lab=qb4}
C {devices/lab_pin.sym} -1560 -670 3 0 {name=l6 sig_type=std_logic lab=qb5}
C {devices/lab_pin.sym} -1190 -670 3 0 {name=l7 sig_type=std_logic lab=qb6}
C {and_gate/and_gate.sym} -3540 -570 0 0 {name=X30}
C {and_gate/and_gate.sym} -3180 -560 0 0 {name=X31}
C {and_gate/and_gate.sym} -2820 -550 0 0 {name=X32}
C {and_gate/and_gate.sym} -2460 -540 0 0 {name=X33}
C {and_gate/and_gate.sym} -2100 -530 0 0 {name=X34}
C {and_gate/and_gate.sym} -1740 -520 0 0 {name=X35}
C {exor_gate/exor_gate.sym} -3060 -1180 3 1 {name=X36}
C {exor_gate/exor_gate.sym} -2700 -1180 3 1 {name=X37}
C {exor_gate/exor_gate.sym} -2340 -1180 3 1 {name=X38}
C {exor_gate/exor_gate.sym} -1990 -1180 3 1 {name=X39}
C {exor_gate/exor_gate.sym} -1640 -1180 3 1 {name=X40}
C {exor_gate/exor_gate.sym} -1270 -1180 3 1 {name=X41}
C {exor_gate/exor_gate.sym} -950 -1180 3 1 {name=X42}
C {devices/ipin.sym} -3660 -740 0 0 {name=p11 lab=Clk}
C {devices/ipin.sym} -3660 -930 0 0 {name=p12 lab=EN}
C {devices/opin.sym} -3160 -530 1 0 {name=p13 lab=Q0}
C {devices/opin.sym} -2800 -530 1 0 {name=p14 lab=Q1}
C {devices/opin.sym} -2440 -530 1 0 {name=p15 lab=Q2}
C {devices/opin.sym} -2090 -530 1 0 {name=p16 lab=Q3}
C {devices/opin.sym} -1740 -530 1 0 {name=p17 lab=Q4}
C {devices/opin.sym} -1370 -530 1 0 {name=p18 lab=Q5}
C {devices/opin.sym} -1050 -530 1 0 {name=p19 lab=Q6}
C {devices/opin.sym} -830 -460 1 0 {name=p20 lab=Q7}
C {devices/lab_pin.sym} -3310 -670 3 0 {name=l8 sig_type=std_logic lab=qb0}
C {devices/lab_pin.sym} -2990 -670 3 0 {name=l9 sig_type=std_logic lab=qb1}
C {devices/lab_pin.sym} -2630 -670 3 0 {name=l10 sig_type=std_logic lab=qb2}
C {devices/lab_pin.sym} -2270 -670 3 0 {name=l11 sig_type=std_logic lab=qb3}
C {devices/lab_pin.sym} -1920 -670 3 0 {name=l12 sig_type=std_logic lab=qb4}
C {devices/lab_pin.sym} -1560 -670 3 0 {name=l13 sig_type=std_logic lab=qb5}
C {devices/lab_pin.sym} -1190 -670 3 0 {name=l14 sig_type=std_logic lab=qb6}
C {T_flip_flop/t_ff_rst.sym} -800 -150 0 0 {name=X1}
C {T_flip_flop/t_ff_rst.sym} -490 -150 0 0 {name=X2}
C {T_flip_flop/t_ff_rst.sym} -130 -150 0 0 {name=X3}
C {T_flip_flop/t_ff_rst.sym} 230 -150 0 0 {name=X4}
C {T_flip_flop/t_ff_rst.sym} 590 -150 0 0 {name=X5}
C {T_flip_flop/t_ff_rst.sym} 950 -150 0 0 {name=X6}
C {T_flip_flop/t_ff_rst.sym} 1310 -150 0 0 {name=X7}
C {T_flip_flop/t_ff_rst.sym} 1670 -150 0 0 {name=X8}
C {devices/ipin.sym} -3660 -700 0 0 {name=p21 lab=RST}
