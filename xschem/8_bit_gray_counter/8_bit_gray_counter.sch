v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1320 -440 2430 -440 { lab=Clk}
N 2430 -460 2430 -440 { lab=Clk}
N 1450 -460 1450 -440 { lab=Clk}
N 1810 -460 1810 -440 { lab=Clk}
N 2130 -460 2130 -440 { lab=Clk}
N -80 -440 0 -440 { lab=Clk}
N 0 -440 1110 -440 { lab=Clk}
N 1110 -460 1110 -440 { lab=Clk}
N 490 -460 490 -440 { lab=Clk}
N 130 -460 130 -440 { lab=Clk}
N 600 -720 600 -630 { lab=#net1}
N 600 -770 600 -720 { lab=#net1}
N 240 -840 380 -840 { lab=EN}
N 380 -810 380 -630 { lab=#net2}
N 520 -830 600 -830 { lab=#net1}
N 600 -830 600 -770 { lab=#net1}
N 360 -630 380 -630 { lab=#net2}
N 240 -840 240 -630 { lab=EN}
N 0 -630 20 -630 { lab=#net3}
N 600 -830 670 -830 { lab=#net1}
N 670 -800 670 -630 { lab=#net4}
N 890 -820 890 -630 { lab=#net5}
N 810 -820 890 -820 { lab=#net5}
N 650 -630 670 -630 { lab=#net4}
N 890 -820 1000 -820 { lab=#net5}
N 1000 -790 1000 -630 { lab=#net6}
N 1140 -810 1220 -810 { lab=#net7}
N 1220 -810 1220 -630 { lab=#net7}
N 980 -630 1000 -630 { lab=#net6}
N 1220 -810 1290 -810 { lab=#net7}
N 780 -460 780 -440 { lab=Clk}
N 1110 -440 1320 -440 { lab=Clk}
N 1290 -810 1340 -810 { lab=#net7}
N 1340 -780 1340 -630 { lab=#net8}
N 1480 -800 1700 -800 { lab=#net9}
N 1560 -800 1560 -630 { lab=#net9}
N 1700 -770 1700 -630 { lab=#net10}
N 1840 -790 1920 -790 { lab=#net11}
N 1920 -790 1920 -630 { lab=#net11}
N 1920 -790 2020 -790 { lab=#net11}
N 2020 -760 2020 -630 { lab=#net12}
N 2160 -780 2240 -780 { lab=#net13}
N 2240 -780 2240 -630 { lab=#net13}
N 2240 -780 2320 -780 { lab=#net13}
N 2320 -750 2320 -630 { lab=Q7}
N 2460 -770 2540 -770 { lab=#net14}
N 2540 -770 2540 -630 { lab=#net14}
N 2290 -630 2320 -630 { lab=Q7}
N 1980 -630 2020 -630 { lab=#net12}
N 1660 -630 1700 -630 { lab=#net10}
N 1300 -630 1340 -630 { lab=#net8}
N 960 -630 980 -630 { lab=#net6}
N 640 -630 650 -630 { lab=#net4}
N 330 -630 360 -630 { lab=#net2}
N 240 -630 240 -560 { lab=EN}
N 330 -880 330 -630 { lab=#net2}
N -0 -880 -0 -630 { lab=#net3}
N -0 -880 90 -880 { lab=#net3}
N 120 -880 330 -880 { lab=#net2}
N 110 -1030 110 -1010 { lab=Q0}
N 330 -880 470 -880 { lab=#net2}
N 640 -880 640 -630 { lab=#net4}
N 540 -880 640 -880 { lab=#net4}
N 500 -880 540 -880 { lab=#net4}
N 490 -1030 490 -1010 { lab=Q1}
N 640 -880 760 -880 { lab=#net4}
N 960 -880 960 -630 { lab=#net6}
N 820 -880 960 -880 { lab=#net6}
N 790 -880 820 -880 { lab=#net6}
N 780 -1030 780 -1010 { lab=Q2}
N 960 -880 1090 -880 { lab=#net6}
N 1300 -880 1300 -630 { lab=#net8}
N 1160 -880 1300 -880 { lab=#net8}
N 1120 -880 1160 -880 { lab=#net8}
N 1110 -1030 1110 -1010 { lab=Q3}
N 1660 -880 1660 -630 { lab=#net10}
N 1530 -880 1660 -880 { lab=#net10}
N 1300 -880 1440 -880 { lab=#net8}
N 1470 -880 1530 -880 { lab=#net10}
N 1460 -1030 1460 -1010 { lab=Q4}
N 1660 -880 1790 -880 { lab=#net10}
N 1980 -880 1980 -630 { lab=#net12}
N 1880 -880 1980 -880 { lab=#net12}
N 1820 -880 1880 -880 { lab=#net12}
N 1810 -1030 1810 -1010 { lab=Q5}
N 2290 -880 2290 -630 { lab=Q7}
N 2170 -880 2290 -880 { lab=Q7}
N 1980 -880 2110 -880 { lab=#net12}
N 2140 -880 2170 -880 { lab=Q7}
N 2130 -1030 2130 -1010 { lab=Q6}
N 2290 -880 2410 -880 { lab=Q7}
N 2410 -1030 2410 -880 { lab=Q7}
N 240 -560 240 -420 { lab=EN}
N 240 -420 240 -380 { lab=EN}
N -80 -380 240 -380 { lab=EN}
C {T_flip_flop/T_flip_flop.sym} 220 -330 0 1 {name=X1}
C {T_flip_flop/T_flip_flop.sym} 580 -330 0 1 {name=X2}
C {T_flip_flop/T_flip_flop.sym} 870 -330 0 1 {name=X3}
C {T_flip_flop/T_flip_flop.sym} 1200 -330 0 1 {name=X4}
C {T_flip_flop/T_flip_flop.sym} 1540 -330 0 1 {name=X5}
C {T_flip_flop/T_flip_flop.sym} 1900 -330 0 1 {name=X6}
C {T_flip_flop/T_flip_flop.sym} 2220 -330 0 1 {name=X7}
C {T_flip_flop/T_flip_flop.sym} 2520 -330 0 1 {name=X8}
C {and_gate/and_gate.sym} -120 -340 0 0 {name=X9}
C {and_gate/and_gate.sym} 170 -330 0 0 {name=X10}
C {and_gate/and_gate.sym} 500 -320 0 0 {name=X11}
C {and_gate/and_gate.sym} 840 -310 0 0 {name=X12}
C {and_gate/and_gate.sym} 1200 -300 0 0 {name=X13}
C {and_gate/and_gate.sym} 1520 -290 0 0 {name=X14}
C {and_gate/and_gate.sym} 1820 -280 0 0 {name=X15}
C {exor_gate/exor_gate.sym} 10 -370 1 1 {name=X16}
C {exor_gate/exor_gate.sym} 390 -370 1 1 {name=X17}
C {exor_gate/exor_gate.sym} 680 -370 1 1 {name=X18}
C {exor_gate/exor_gate.sym} 1010 -370 1 1 {name=X19}
C {exor_gate/exor_gate.sym} 1360 -370 1 1 {name=X20}
C {exor_gate/exor_gate.sym} 1710 -370 1 1 {name=X21}
C {exor_gate/exor_gate.sym} 2030 -370 1 1 {name=X22}
C {devices/ipin.sym} -70 -440 0 0 {name=p1 lab=Clk}
C {devices/ipin.sym} -70 -380 0 0 {name=p2 lab=EN}
C {devices/opin.sym} 110 -1020 3 0 {name=p3 lab=Q0}
C {devices/opin.sym} 490 -1020 3 0 {name=p4 lab=Q1}
C {devices/opin.sym} 780 -1020 3 0 {name=p5 lab=Q2}
C {devices/opin.sym} 1110 -1020 3 0 {name=p6 lab=Q3}
C {devices/opin.sym} 1460 -1020 3 0 {name=p7 lab=Q4}
C {devices/opin.sym} 1810 -1020 3 0 {name=p8 lab=Q5}
C {devices/opin.sym} 2130 -1020 3 0 {name=p9 lab=Q6}
C {devices/opin.sym} 2410 -1020 3 0 {name=p10 lab=Q7}
